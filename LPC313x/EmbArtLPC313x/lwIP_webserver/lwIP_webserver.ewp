# IAR project lwIP_webserver.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC3131 NXP LPC3131
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; board; modules; lwip-1.3.1\src; lwip-1.3.1\src\include; lwip-1.3.1\src\include\ipv4; lwip-1.3.1\src\arch\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC313x_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DBG_SDRAM
  AARM.ADefines: DBG_SDRAM
  ILINK.IlinkIcfFile: config/LPC313x_SDRAM.icf
configuration Debug_SPINOR_Boot_iRAM (ARM, debug)
  as the first configuration, except:
configuration Debug_SPINOR_Boot_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DBG_SDRAM; BOOT_LEVEL_2
  AARM.ADefines: DBG_SDRAM; BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC313x_Boot_level_2.icf
  group (top)
    lwip-1.3.1/src/include/: lwipopts.h
    ./: main.c readme.txt
  group app
    ./: httpd.c
  group lwIP/api
    lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP/arch
    lwip-1.3.1/src/arch/: sys_arch.c
  group lwIP/arch/netif
    lwip-1.3.1/src/arch/netif/: dm9000_ea_lpc313x.c ea_lpc313x_if.c
  group lwIP/core
    lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwIP/core/ipv4
    lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwIP/core/ipv6
    lwip-1.3.1/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group lwIP/core/snmp
    lwip-1.3.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwIP/netif
    lwip-1.3.1/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group MMU
    board/: arm926ej_cp15_drv.c
  group modules
    modules/: drv_cgu.c drv_intc.c drv_spi.c drv_spinor.c
    board/: spinor_bootloader.c
  group Startup
    board/: cstartup.s vectors.s
