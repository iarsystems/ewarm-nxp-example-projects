# IAR project MassStorage.ewp, settings and files
configuration Debug_SDRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC3131 NXP LPC3131
  ICCARM.CCDefines: DBG_SDRAM; EA_LPC_313x
  ICCARM.CCIncludePath2: $PROJ_DIR$; app\; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: DBG_SDRAM
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC313x_SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_SPINOR_Boot_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DBG_SDRAM; BOOT_LEVEL_2; EA_LPC_313x
  AARM.ADefines: DBG_SDRAM; BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC313x_Boot_level_2.icf
  group (top)
    app/: main.c
    ./: readme.txt
  group Board
    board/: cstartup.s vectors.s
  group LUNs
    app/: lun.c
  group LUNs/RAM Disc
    app/: ram_dsk.c ram_dsk_desc.c
  group MMU
    board/: arm926ej_cp15_drv.c
  group Modules
    modules/: drv_cgu.c drv_intc.c drv_spi.c drv_spinor.c
    board/: spinor_bootloader.c
  group USB/Class
    app/: scsi.c scsi_ll.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
