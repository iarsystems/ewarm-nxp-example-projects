<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GettingStarted.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>GettingStarted</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Debug_SDRAM</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Debug_SPINOR_Boot_iRAM</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Debug_SPINOR_Boot_SDRAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
