<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/MassStorage.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>MassStorage</project>
        <configuration>Debug_SDRAM</configuration>
      </member>
      <member>
        <project>MassStorage</project>
        <configuration>Debug_SPINOR_Boot_SDRAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
