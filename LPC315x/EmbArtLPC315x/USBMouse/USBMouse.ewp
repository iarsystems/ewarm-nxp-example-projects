# IAR project USBMouse.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC3152 NXP LPC3152
  ICCARM.CCDefines: EA_LPC_315x
  ICCARM.CCIncludePath2: $PROJ_DIR$; app\; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC315x_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DBG_SDRAM; EA_LPC_315x
  AARM.ADefines: DBG_SDRAM
  ILINK.IlinkIcfFile: config/LPC315x_SDRAM.icf
configuration Debug_SPINOR_Boot_iRAM (ARM, debug)
  as the first configuration, except:
configuration Debug_SPINOR_Boot_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DBG_SDRAM; BOOT_LEVEL_2; EA_LPC_315x
  AARM.ADefines: DBG_SDRAM; BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC315x_Boot_level_2.icf
  group (top)
    app/: buttons.c main.c
    ./: readme.txt
  group Board
    board/: cstartup.s vectors.s
  group MMU
    board/: arm926ej_cp15_drv.c
  group modules
    modules/: drv_cgu.c drv_intc.c drv_spi.c drv_spinor.c lpc315x_i2c_driver.c lpc315x_pca9532_driver.c
    board/: spinor_bootloader.c
  group USB/Class
    app/: hid_mouse.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
