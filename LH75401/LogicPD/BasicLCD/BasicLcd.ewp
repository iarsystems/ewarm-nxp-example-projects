# IAR project BasicLcd.ewp, settings and files
configuration DebugRunFromFlash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LH75401LPDSDK NXP LH75401LPDSDK
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: BasicLcd.out
  ILINK.IlinkIcfFile: config/StandAloneFlashLH75401LPD.icf
  group (top)
    app/: main.c Paint_bmp.c
  group Common
    board/: lh754xx_low_init.c
  group Modules
    modules/: lcd_drv.c lh754xx_vic.c lq035q7db02_lcd.c touch_scr.c
