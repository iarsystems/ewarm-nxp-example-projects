# IAR project led_blink.ewp, settings and files
configuration DebugRunFromiRam (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LH75401LPDSDK NXP LH75401LPDSDK
  ICCARM.CCIncludePath2: ; board\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: led_blink.out
  ILINK.IlinkIcfFile: config/DebugiRamLH75401LPD.icf
configuration DebugRunFromFlash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/StandAloneFlashLH75401LPD.icf
  group (top)
    ./: main.c
  group Common
    board/: lh754xx_low_init.c
