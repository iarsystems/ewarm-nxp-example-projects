<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/led_blink.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>led_blink</project>
        <configuration>DebugRunFromFlash</configuration>
      </member>
      <member>
        <project>led_blink</project>
        <configuration>DebugRunFromiRam</configuration>
      </member>
      <member>
        <project>led_blink</project>
        <configuration>DebugRunFromxRam</configuration>
      </member>
      <member>
        <project>led_blink</project>
        <configuration>StandaloneRunFromFlash</configuration>
      </member>
      <member>
        <project>led_blink</project>
        <configuration>StandaloneRunFromxRam</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
