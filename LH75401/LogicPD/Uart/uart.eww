<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/uart.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>uart</project>
        <configuration>DebugRunFromFlash</configuration>
      </member>
      <member>
        <project>uart</project>
        <configuration>DebugRunFromiRam</configuration>
      </member>
      <member>
        <project>uart</project>
        <configuration>DebugRunFromxRam</configuration>
      </member>
      <member>
        <project>uart</project>
        <configuration>StandaloneRunFromFlash</configuration>
      </member>
      <member>
        <project>uart</project>
        <configuration>StandaloneRunFromxRam</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
