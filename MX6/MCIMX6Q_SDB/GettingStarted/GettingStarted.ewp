# IAR project GettingStarted.ewp, settings and files
configuration OCRAM_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Q6 NXP MCIMX6Q6
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 3
  ICCARM.CCDefines: OCRAM_DEBUG
  ICCARM.CCIncludePath2: ; ..\..\drivers\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.hex
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/mcimx6q_ocram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DDR_DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DEBUG
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkIcfFile: config/mcimx6q_ddr.icf
  group (top)
    ./: cstartup.s main.c readme.txt
  group drivers
    ../../drivers/: drv_A9_timers.c drv_gic.c
