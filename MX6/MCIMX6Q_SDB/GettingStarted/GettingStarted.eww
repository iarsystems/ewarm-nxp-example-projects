<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GettingStarted.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>GettingStarted</project>
        <configuration>OCRAM_DEBUG</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>DDR_DEBUG</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
