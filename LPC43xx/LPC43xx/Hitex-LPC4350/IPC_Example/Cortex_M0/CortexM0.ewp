# IAR project CortexM0.ewp, settings and files
configuration NORFLASH (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __IPC_SLAVE__
  ICCARM.CCIncludePath2: modules\; ..\ipc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: M0.bin
  ILINK.IlinkOutputFile: CortexM0_NORFLASH.out
  ILINK.IlinkIcfFile: config/Hitex-LPC4350_M0_extflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__; __IPC_SLAVE__
  ICCARM.CCIncludePath2: ..\ipc\; modules\
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: CortexM0_IRAM.out
  ILINK.IlinkIcfFile: config/Hitex-LPC4350_M0_iram.icf
configuration SPIFI (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkOutputFile: CortexM0_SPIFI.out
configuration IFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M0 NXP LPC4357_M0
  AARM.ADefines: __IFLASH_MODE__
  ILINK.IlinkOutputFile: CortexM0_IFLASH.out
  group (top)
    ./: main.c startup_M.s
    ../: readme.txt
  group IPC
    ../ipc/: ipc.c ipc.h
  group modules
    modules/: drv_nvic.c i2c_drv.c
