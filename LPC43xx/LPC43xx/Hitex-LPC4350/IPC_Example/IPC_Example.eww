<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Cortex_M4/CortexM4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Cortex_M0/CortexM0.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>NORFLASH</name>
      <member>
        <project>CortexM0</project>
        <configuration>NORFLASH</configuration>
      </member>
      <member>
        <project>CortexM4</project>
        <configuration>NORFLASH</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>SPIFI</name>
      <member>
        <project>CortexM0</project>
        <configuration>SPIFI</configuration>
      </member>
      <member>
        <project>CortexM4</project>
        <configuration>SPIFI</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CortexM0</project>
        <configuration>IFLASH</configuration>
      </member>
      <member>
        <project>CortexM0</project>
        <configuration>IRAM</configuration>
      </member>
      <member>
        <project>CortexM0</project>
        <configuration>NORFLASH</configuration>
      </member>
      <member>
        <project>CortexM0</project>
        <configuration>SPIFI</configuration>
      </member>
      <member>
        <project>CortexM4</project>
        <configuration>IFLASH</configuration>
      </member>
      <member>
        <project>CortexM4</project>
        <configuration>IRAM</configuration>
      </member>
      <member>
        <project>CortexM4</project>
        <configuration>NORFLASH</configuration>
      </member>
      <member>
        <project>CortexM4</project>
        <configuration>SPIFI</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>IFLASH</name>
      <member>
        <project>CortexM0</project>
        <configuration>IFLASH</configuration>
      </member>
      <member>
        <project>CortexM4</project>
        <configuration>IFLASH</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>IRAM</name>
      <member>
        <project>CortexM0</project>
        <configuration>IRAM</configuration>
      </member>
      <member>
        <project>CortexM4</project>
        <configuration>IRAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
