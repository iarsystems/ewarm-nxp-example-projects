# IAR project CortexM4.ewp, settings and files
configuration NORFLASH (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CortexM4.srec
  ILINK.IlinkOutputFile: CortexM4_NORFLASH.out
  ILINK.IlinkKeepSymbols: M0_APPLICATION
  ILINK.IlinkIcfFile: config/Hitex-LPC4350_M4_norflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__
  ILINK.IlinkOutputFile: CortexM4_IRAM.out
  ILINK.IlinkIcfFile: config/Hitex-LPC4350_M4_iram.icf
configuration SPIFI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __SPIFI_MODE__
  ILINK.IlinkOutputFile: CortexM4_SPIFI.out
  ILINK.IlinkIcfFile: config/Hitex-LPC4350_M4_SPIFI.icf
configuration IFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: __IFLASH_MODE__
  AARM.ADefines: __IFLASH_MODE__
  ILINK.IlinkOutputFile: CortexM4_IFLASH.out
  group (top)
    ./: init.c main.c startup_M.s
    ../: readme.txt
  group modules
    modules/: drv_nvic.c i2c_drv.c
