# IAR project Mbx_Demo_M4.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=1; CORE_M4; IPC_MASTER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\..\Core\Device\NXP\LPC43xx\Include\; ..\..\..\..\..\Drivers\include; ..\..\platform\; ..\..\M0\M0_rpc\; ..\..\M4\M4_rpc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Mbx_Demo_M4.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: M0_IMAGE
  ILINK.IlinkIcfFile: ../config/ldscript_iram_dualcore_M4_iar.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Drivers\lib\spifi_drv_M4.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration EXFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__=0; CORE_M4; IPC_MASTER; EXT_FLASH
  ILINK.IlinkIcfFile: ../config/ldscript_exflash_dualcore_M4_iar.icf
  group CMSIS
    ../../M4/: system_LPC43xx.c
  group Drivers
    ../../../../../Drivers/source/: debug_frmwrk.c lpc43xx_cgu.c lpc43xx_emc.c lpc43xx_scu.c lpc43xx_uart.c
    ../../../../BOOTFAST/Fast_Gpio_LedBlinky/: Hitex_Fast_Startup.c
  group IPC
    ../../../../../Drivers/source/: ipc_buffer.c ipc_mbx.c
  group Main
    ../../M4/: main.c
    ../../M4/M4_rpc/: master_mbx_callbacks.c
  group Platform
    ../../../../../Core/Device/NXP/LPC43xx/Source/: fpu_init.c
    ../../platform/: platform_config.c
  group Readme
    ../../: abstract.txt
  group Startup
    ../../../../Common/IAR/startup/: startup_LPC43xx.s
