# IAR project Mbx_Demo_M0.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=1; USED_UART_DEBUG_PORT=1; CORE_M0; IPC_SLAVE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\..\Core\Device\NXP\LPC43xx\Include\; ..\..\..\..\..\Drivers\include; ..\..\platform\; ..\..\M0\M0_rpc\; ..\..\M4\M4_rpc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: M0_image.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../config/ldscript_iram_dualcore_M0_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ../../../../../Drivers/source/: debug_frmwrk.c lpc43xx_cgu.c lpc43xx_scu.c lpc43xx_uart.c
  group IPC
    ../../../../../Drivers/source/: ipc_buffer.c ipc_mbx.c
  group Main
    ../../M0/: main.c
    ../../M0/M0_rpc/: slave_mbx_callbacks.c
  group Platform
    ../../platform/: platform_config.h
  group Readme
    ../../: abstract.txt
  group Startup
    ../../../../Common/IAR/startup/: startup_LPC43xx_M0.s
