<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SPIFI_Test/IAR/Spifi_Test.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Spifi_Test</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Spifi_Test</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
