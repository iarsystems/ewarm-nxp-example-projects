<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Ssp_Master/IAR/Ssp_Master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Ssp_MicroWire/IAR/Ssp_MicroWire.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Ssp_Slave/IAR/Ssp_Slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Ssp_Ti/IAR/Ssp_Ti.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Ssp_Master</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Ssp_Master</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Ssp_MicroWire</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Ssp_MicroWire</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Ssp_Slave</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Ssp_Slave</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Ssp_Ti</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Ssp_Ti</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
