<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Wdt_Interrupt/IAR/Wdt_Interrupt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Wdt_Interrupt</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Wdt_Interrupt</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
