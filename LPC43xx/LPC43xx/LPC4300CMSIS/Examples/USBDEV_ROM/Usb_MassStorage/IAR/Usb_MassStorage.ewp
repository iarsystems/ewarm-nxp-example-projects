# IAR project Usb_MassStorage.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=1; __BUILD_WITH_EXAMPLE__=1; CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\Core\Device\NXP\LPC43xx\Include\; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_burst.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../Examples/Common/IAR/config/ldscript_iram_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration EXFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__=0; __BUILD_WITH_EXAMPLE__=1; CORE_M4
  ILINK.IlinkIcfFile: ../../../../Examples/Common/IAR/config/ldscript_exflash_iar.icf
  group CMSIS
    ../../../Common/: system_LPC43xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c Font5x7.c LCDTerm.c lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_uart.c sdio.c
  group Main
    ../: main.c mem_usbdesc.c usbd_msc_sdio.c
  group Readme
    ../: Abstract.txt
  group Startup
    ../../../Common/IAR/startup/: startup_LPC43xx.s
