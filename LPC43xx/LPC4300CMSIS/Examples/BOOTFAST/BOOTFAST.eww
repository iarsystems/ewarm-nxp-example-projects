<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Fast_Gpio_LedBlinky/IAR/Fast_Gpio_LedBlinky.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Fast_Gpio_LedBlinky</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Fast_Gpio_LedBlinky</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
