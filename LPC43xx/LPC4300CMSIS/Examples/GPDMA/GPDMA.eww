<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Gpdma_Flash2Ram/IAR/Gpdma_Flash2Ram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Gpdma_LinkList/IAR/Gpdma_LinkList.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Gpdma_Ram2Ram/IAR/Gpdma_Ram2Ram.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Gpdma_Flash2Ram</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Gpdma_LinkList</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Gpdma_LinkList</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Gpdma_Ram2Ram</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Gpdma_Ram2Ram</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
