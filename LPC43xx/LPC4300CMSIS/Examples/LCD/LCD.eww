<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Lcd_Demo/IAR/Lcd_Demo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Lcd_Demo</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Lcd_Demo</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
