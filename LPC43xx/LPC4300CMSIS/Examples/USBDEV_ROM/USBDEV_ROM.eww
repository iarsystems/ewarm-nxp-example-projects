<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Usb_Composite/IAR/Usb_Composite.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Usb_Dfu/IAR/Usb_Dfu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Usb_Hid/IAR/Usb_Hid.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Usb_MassStorage/IAR/Usb_MassStorage.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Usb_MassStorage</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Usb_Composite</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Usb_Composite</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Usb_Dfu</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Usb_Dfu</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Usb_Hid</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Usb_Hid</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Usb_MassStorage</project>
        <configuration>EXFLASH</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
