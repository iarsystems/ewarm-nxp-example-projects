<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Emc_NorFlash/IAR/Emc_NorFlash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Emc_Sdram/IAR/Emc_Sdram.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Emc_NorFlash</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Emc_Sdram</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Emc_Sdram</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
