<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Uart_Autobaud/IAR/Uart_Autobaud.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_Dma/IAR/Uart_Dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_Interrupt/IAR/Uart_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_Polling/IAR/Uart_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_Rs485Master/IAR/Uart_Rs485Master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_Rs485Slave/IAR/Uart_Rs485Slave.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Uart_Autobaud</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Uart_Autobaud</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Uart_Dma</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Uart_Dma</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Uart_Interrupt</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Uart_Interrupt</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Uart_Polling</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Uart_Polling</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Uart_Rs485Master</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Uart_Rs485Slave</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
