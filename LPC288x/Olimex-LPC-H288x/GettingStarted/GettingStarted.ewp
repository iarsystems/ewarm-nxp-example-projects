# IAR project GettingStarted.ewp, settings and files
configuration iRam Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2888 NXP LPC2888
  ICCARM.CCIncludePath2: board/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/LPC2888_iRam.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iFlash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IFLASH_BOOT
  ILINK.IlinkIcfFile: config/LPC2888_iFlash.icf
configuration xFlash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: XFLASH_INIT; IFLASH_BOOT
  ILINK.IlinkIcfFile: config/LPC2888_xFlash.icf
  group (top)
    ./: main.c readme.txt
  group Startup
    board/: cstartup.s irq_handler.s lpc288x_low_init.c
