# IAR project TouchDemo.ewp, settings and files
configuration SDRAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MCIMX25_KSK NXP MCIMX25_KSK
  ICCARM.CCDefines: SDRAM_EXEC
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/mcimx25_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NAND-SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  AARM.ADefines: _SRAM_EXEC
  group (top)
    ./: main.c readme.txt
  group Fonts
    ./: Terminal_18_24x12_V.c Terminal_6_10x6_V.c Terminal_9_12x6_V.c
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Modules
    modules/: drv_asic.c drv_CS43L22.c drv_glcd.c drv_i2c1.c drv_MC34704.c drv_touch_scr.c
  group Pictures
    ./: freescale_logo.c iar_logo.c
  group Startup
    board/: bootloader.c bootstartup.s low_level_init.c MX25_cstartup.s
