# IAR project Dhrystone.ewp, settings and files
configuration SRAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MCIMX25_KSK NXP MCIMX25_KSK
  ICCARM.CCDefines: SRAM_EXEC
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: _SRAM_EXEC
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/mcimx25_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM High optimization by speed (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SDRAM_EXEC
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: config/mcimx25_sdram.icf
configuration SDRAM High optimization by speed (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SDRAM_EXEC
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config/mcimx25_sdram.icf
  group (top)
    modules/: drv_asic.c
    ./: main.c
  group Drystone
    DHRYSTONE_2_1/: dhry_1.c dhry_2.c
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Other
    ./: readme.txt
  group Startup
    board/: low_level_init.c MX25_cstartup.s
