<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GettingStarted.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>GettingStarted</project>
        <configuration>SDRAM Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>SRAM Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>NAND-SDRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
