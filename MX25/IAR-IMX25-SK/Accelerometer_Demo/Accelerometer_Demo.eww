<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Accelerometer_Demo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Accelerometer_Demo</project>
        <configuration>NAND-SDRAM Debug</configuration>
      </member>
      <member>
        <project>Accelerometer_Demo</project>
        <configuration>SDRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
