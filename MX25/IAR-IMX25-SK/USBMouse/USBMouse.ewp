# IAR project USBMouse.ewp, settings and files
configuration SDRAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MCIMX25_KSK NXP MCIMX25_KSK
  ICCARM.CCDefines: SDRAM_EXEC
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/mcimx25_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_EXEC
  ICCARM.CCOptLevel: 1
  AARM.ADefines: _SRAM_EXEC
  ILINK.IlinkIcfFile: config/mcimx25_sram.icf
configuration NAND-SDRAM Debug (ARM, debug)
  as the first configuration, except:
  group (top)
    app/: main.c
    ./: readme.txt
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Modules
    modules/: drv_asic.c drv_i2c1.c drv_MC34704.c drv_MMA7660FC.c
  group Startup
    board/: bootloader.c bootstartup.s low_level_init.c MX25_cstartup.s
  group USB/Class
    app/: hid_mouse.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
