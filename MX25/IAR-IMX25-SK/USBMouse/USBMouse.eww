<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USBMouse.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USBMouse</project>
        <configuration>SDRAM Debug</configuration>
      </member>
      <member>
        <project>USBMouse</project>
        <configuration>SRAM Debug</configuration>
      </member>
      <member>
        <project>USBMouse</project>
        <configuration>NAND-SDRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
