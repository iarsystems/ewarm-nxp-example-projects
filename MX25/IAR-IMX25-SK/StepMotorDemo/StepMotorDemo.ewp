# IAR project StepMotorDemo.ewp, settings and files
configuration SRAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MCIMX25_KSK NXP MCIMX25_KSK
  ICCARM.CCDefines: SRAM_EXEC
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/mcimx25_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SDRAM_EXEC
  ILINK.IlinkIcfFile: config/mcimx25_sdram.icf
configuration NAND-SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SDRAM_EXEC
  ICCARM.CCOptLevel: 1
  AARM.ADefines: _SRAM_EXEC
  ILINK.IlinkIcfFile: config/mcimx25_sdram.icf
  group (top)
    ./: main.c readme.txt
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Modules
    modules/: drv_adc.c drv_asic.c drv_i2c1.c drv_MC34704.c
  group Startup
    board/: bootloader.c bootstartup.s low_level_init.c MX25_cstartup.s
