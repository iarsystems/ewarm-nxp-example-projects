<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/StepMotorDemo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>StepMotorDemo</project>
        <configuration>NAND-SDRAM Debug</configuration>
      </member>
      <member>
        <project>StepMotorDemo</project>
        <configuration>SDRAM Debug</configuration>
      </member>
      <member>
        <project>StepMotorDemo</project>
        <configuration>SRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
