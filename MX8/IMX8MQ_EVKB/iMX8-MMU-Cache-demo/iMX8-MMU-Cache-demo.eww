<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/iMX8-MMU-Cache-demo.ewp</path>
    </project>
    <batchBuild/>
</workspace>
