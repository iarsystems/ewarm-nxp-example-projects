# IAR project iMX8-MMU-Cache-demo.ewp, settings and files
configuration OCRAM_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MQ7_A53 NXP MIMX8MQ7_A53
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 62
  General.FPU2: 0
  ICCARM.CCIncludePath2: include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iMX8-MMU-Cache-demo.srec
  ILINK.IlinkOutputFile: iMX8-MMU-Cache-demo.out
  ILINK.IlinkIcfFile: config/IMX8-EVK_OCRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup.s exception.s main.c misc.s mmu.c pmu.s
