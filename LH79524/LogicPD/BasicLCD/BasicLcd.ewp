# IAR project BasicLcd.ewp, settings and files
configuration DebugRunFromFlash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LH79524LPDSDK NXP LH79524LPDSDK
  ICCARM.CCDefines: RUN_FROM_FLASH
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: BasicLcd.out
  ILINK.IlinkIcfFile: config/StandAloneFlashLH79524LPD.icf
  group (top)
    app/: main.c Paint_bmp.c
  group Common
    board/: cstartup.s lh79524_low_init.c
  group MMU
    board/: arm720t_cp15_drv.c ttbl.c
  group Modules
    modules/: lcd_drv.c lh7952x_vic.c lq035q7db02_lcd.c touch_scr.c
