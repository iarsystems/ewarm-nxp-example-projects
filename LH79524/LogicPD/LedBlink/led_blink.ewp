# IAR project led_blink.ewp, settings and files
configuration DebugRunFromFlash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LH79524LPDSDK NXP LH79524LPDSDK
  ICCARM.CCDefines: RUN_FROM_FLASH
  ICCARM.CCIncludePath2: ; board\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: led_blink.out
  ILINK.IlinkIcfFile: config/StandAloneFlashLH79524LPD.icf
  group (top)
    ./: main.c
  group Common
    board/: cstartup.s lh79524_low_init.c
  group MMU
    board/: arm720t_cp15_drv.c ttbl.c
