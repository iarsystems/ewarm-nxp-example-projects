# IAR project ocotp_fuses_tower.ewp, settings and files
configuration SRAM (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 NXP VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 48
  General.FPU2: 5
  ICCARM.CCDefines: TOWER
  ICCARM.CCIncludePath2: ..\..\..\..\src\projects\ocotp_fuses; ..\..\..\..\src\common; ..\..\..\..\src\cpu\header; ..\..\..\..\src\cpu; ..\..\..\..\src\drivers\ddr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\header; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ocotp_fuses_tower.bin
  ILINK.IlinkOutputFile: ocotp_fuses.out
  ILINK.IlinkIcfFile: ../../../../build/iar/linker/512KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../../../../src/projects/ocotp_fuses/: tower.h
  group common
    ../../../../src/common/: macros.c printf.c stdlib.c
  group cpu
    ../../../../src/cpu/: startup.c sysinit.c system_Vybrid.c vectors.s write_VBAR.s
  group drivers/ddr
    ../../../../src/drivers/ddr/: ddr.c
  group drivers/lptmr
    ../../../../src/drivers/lptmr/: lpt.c
  group drivers/serial
    ../../../../src/drivers/serial/: serial.c
  group linker
    ../../linker/: 512KB_Ram.icf
  group project
    ../../../../src/projects/ocotp_fuses/: ocotp_fuses.c readme.txt
