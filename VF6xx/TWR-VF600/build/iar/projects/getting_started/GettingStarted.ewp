# IAR project GettingStarted.ewp, settings and files
configuration A5 Debug OCRAM (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 NXP VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 48
  General.FPU2: 5
  ICCARM.CCDefines: TOWER
  ICCARM.CCIncludePath2: ..\..\..\..\src\projects\getting_started; ..\..\..\..\src\common; ..\..\..\..\src\cpu\header; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu_m4; ..\..\..\..\src\drivers\ddr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\..\..\CMSIS\Core\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../build/iar/linker/256KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration M4 Debug OCRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: VF6xx_M4 NXP VF6xx_M4
  General.CoreVariant: 39
  General.FPU2: 0
  ILINK.IlinkIcfFile: ../../linker/256KB_Ram_m4.icf
configuration A5 Debug DDR (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TOWER; DDR_CFG
  ICCARM.CCIncludePath2: ..\..\..\..\src\projects\getting_started; ..\..\..\..\src\common; ..\..\..\..\src\cpu\header; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu_m4; ..\..\..\..\src\drivers\ddr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\..\..\CMSIS\Core\Include
  ILINK.IlinkIcfFile: ../../../../build/iar/linker/128MB_ddr_a5.icf
configuration M4 Debug DDR (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: VF6xx_M4 NXP VF6xx_M4
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TOWER; DDR_CFG
  ILINK.IlinkIcfFile: ../../linker/256KB_Ram_m4.icf
configuration A5 Debug QSPI XIP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TOWER; QSPI_CFG=0
  ICCARM.CCIncludePath2: ..\..\..\..\src\projects\getting_started; ..\..\..\..\src\common; ..\..\..\..\src\cpu\header; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu_m4; ..\..\..\..\src\drivers\ddr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\boot; ..\..\..\..\..\..\..\CMSIS\Core\Include
  ILINK.IlinkIcfFile: ../../../../build/iar/linker/quadspi_xip.icf
configuration A5 Release QSPI to DDR (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TOWER; DDR_CFG
  ICCARM.CCIncludePath2: ..\..\..\..\src\projects\getting_started; ..\..\..\..\src\common; ..\..\..\..\src\cpu\header; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu_m4; ..\..\..\..\src\drivers\ddr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\..\..\..\CMSIS\Core\Include
  ILINK.IlinkIcfFile: ../../../../build/iar/linker/quadspi_ddr.icf
  group (top)
    ../../../../src/projects/getting_started/: main.c tower.h vectors_m4.h
    ./: readme.txt
  group boot
    ../../../../src/boot/: quadspi_boot.c
  group common
    ../../../../src/common/: common.h macros.c macros.h printf.c printf.h stdlib.c stdlib.h typedefs.h typedefs_UINT8.h uif.h uif_cmd.h
  group CPU/A5
    ../../../../src/cpu/: startup.c sysinit.c system_Vybrid.c vectors.s write_VBAR.s
  group CPU/M4
    ../../../../src/cpu_m4/: arm_cm4.c crt0_m4.s start_m4.c vectors_m4.c
  group drivers/ddr
    ../../../../src/drivers/ddr/: ddr.c
  group drivers/lptmr
    ../../../../src/drivers/lptmr/: lpt.c
  group drivers/serial
    ../../../../src/drivers/serial/: serial.c
