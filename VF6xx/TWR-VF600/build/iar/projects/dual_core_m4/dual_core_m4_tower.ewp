# IAR project dual_core_m4_tower.ewp, settings and files
configuration SRAM (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_M4 NXP VF6xx_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TOWER
  ICCARM.CCIncludePath2: ..\..\..\..\src\projects\dual_core_m4; ..\..\..\..\src\common; ..\..\..\..\src\cpu\header; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu_m4; ..\..\..\..\src\platforms; ..\..\..\..\src\drivers\ddr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\header; ..\..\..\..\..\..\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  postbuild: "$EW_DIR$\arm\bin\isymexport" "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$_slave.o" --show_entry_as=__iar_program_start_slave
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../build/iar/linker/256KB_Ram_m4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../../../../src/projects/dual_core_m4/: tower.h vectors_m4.h
  group common
    ../../../../src/common/: macros.c printf.c stdlib.c
  group cpu_m4
    ../../../../src/cpu_m4/: arm_cm4.c crt0_m4.s start_m4.c vectors_m4.c
  group drivers/ddr
    ../../../../src/drivers/ddr/: ddr.c
  group drivers/lptmr
    ../../../../src/drivers/lptmr/: lpt.c
  group drivers/serial
    ../../../../src/drivers/serial/: serial.c
  group linker
    ../../linker/: 256KB_Ram_m4.icf
  group project
    ../../../../src/projects/dual_core_m4/: dual_core_m4.c
