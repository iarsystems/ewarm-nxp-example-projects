# IAR project dual_core_tower.ewp, settings and files
configuration SRAM (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 NXP VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 48
  General.FPU2: 5
  ICCARM.CCDefines: TOWER
  ICCARM.CCIncludePath2: ..\..\..\..\src\common; ..\..\..\..\src\cpu\header; ..\..\..\..\src\cpu; ..\..\..\..\src\drivers\ddr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\header; ..\..\..\..\src\projects\dual_core; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dual_core_tower.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: m4_code
  ILINK.IlinkIcfFile: ../../../../build/iar/linker/256KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CoreA5 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\src\common; ..\..\..\..\src\cpu\header; ..\..\..\..\src\cpu; ..\..\..\..\src\drivers\ddr; ..\..\..\..\src\drivers\serial; ..\..\..\..\src\drivers\lptmr; ..\..\..\..\src\header; ..\..\..\..\src\projects\dual_core; $TOOLKIT_DIR$\CMSIS\Include
  group (top)
    ../dual_core_m4/TOWER_SRAM/Exe/: dual_core_m4_tower_slave.o
    ./: readme.txt
  group board
    ../../../../src/projects/dual_core/: tower.h
  group common
    ../../../../src/common/: common.h macros.c macros.h printf.c printf.h stdlib.c stdlib.h typedefs.h typedefs_UINT8.h uif.h uif_cmd.h
  group cpu
    ../../../../src/cpu/: startup.c sysinit.c system_Vybrid.c vectors.s write_VBAR.s
  group drivers/ddr
    ../../../../src/drivers/ddr/: ddr.c
  group drivers/lptmr
    ../../../../src/drivers/lptmr/: lpt.c
  group drivers/serial
    ../../../../src/drivers/serial/: serial.c
  group linker
    ../../linker/: 256KB_Ram.icf
  group project
    ../../../../src/projects/dual_core/: dual_core.c
