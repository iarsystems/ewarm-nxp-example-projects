# IAR project mci_fat_test.ewp, settings and files
configuration FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  ICCARM.CCDiagSuppress: Pa082, Pe188, Pe068, Pe047
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\include; ..\..\..\..\..\..\lpc\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: MAPMODEFLAG=0
  OBJCOPY.OOCOutputFile: dac_ex.srec
  ILINK.IlinkOutputFile: mci_fat_test.out
  ILINK.IlinkIcfFile: ../linker/lpc23xx_rom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: comm.c diskio.c ff.c gettime_lpcrtc.c irq.c mci_fat_test.c monitor.c rtc.c target.c timer.c
    ../../startup/: crt0_iar.asm
    ../../../../lib/: lib_lpc23xx_iar.a
    ../../source/: mcb2300_init.c
