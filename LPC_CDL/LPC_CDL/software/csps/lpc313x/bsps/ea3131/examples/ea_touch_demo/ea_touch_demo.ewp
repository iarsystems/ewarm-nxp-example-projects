# IAR project ea_touch_demo.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC3131 NXP LPC3131
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lpc\include; ..\..\..\..\include; ..\..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: adc_example.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../linker/LPC313x_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iRAM_boot_from_SPINOR (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: calibapp.c calibrate.c font5x7.c lcd_grph.c lcd_hw.c main.c touch.c
    ../common/: cstartup.s main_iar.c
    ../: readme.txt
  group BSP
    ../../source/: ea3131_board.c ea3131_spinor.c lpc313x_pca9532_driver.c
    ../../startup/: ea3131_startup.c
  group Common
    ../../../../../../lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x16.c lpc_rom8x8.c lpc_string.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
  group CSP
    ../../../../source/: lpc313x_adc10b_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_crc_driver.c lpc313x_dma_driver.c lpc313x_evt_driver.c lpc313x_i2c_driver.c lpc313x_i2s_driver.c lpc313x_intc_driver.c lpc313x_ipint_driver.c lpc313x_mci_driver.c lpc313x_nand_driver.c lpc313x_pwm_driver.c lpc313x_spi_driver.c lpc313x_timer_driver.c lpc313x_uart_driver.c lpc313x_vectors.s lpc313x_wdt_driver.c
