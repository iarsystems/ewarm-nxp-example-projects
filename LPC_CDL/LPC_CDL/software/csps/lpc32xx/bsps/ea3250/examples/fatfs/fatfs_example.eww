<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/fatfs_example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>fatfs_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>fatfs_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>fatfs_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
