<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/adc/adc_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ea_acc_demo/ea_acc_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ea_lcd_demo/ea_lcd_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ea_pca9532/ea_pca9532.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ea_touch_demo/ea_touch_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ea_xbee/ea_xbee.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/i2s/i2s_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/nand/nand_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pca9532_i2c/pca9532_i2c_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pwm/pwm_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sdcard_poll/sdcard_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sdram_dhry/sdram_dhry.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/spi_prog/spi_prog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/timer_int/timer_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/uart/uart_example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>adc_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>adc_example</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>i2s_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>i2s_example</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>nand_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>nand_example</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>pca9532_i2c_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>pca9532_i2c_example</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>pwm_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>pwm_example</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>sdcard_poll</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>sdcard_poll</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>spi_prog</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>usbmem_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>usbmem_example</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>ea_acc_demo</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>ea_acc_demo</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>ea_lcd_demo</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>ea_lcd_demo</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>ea_pca9532</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>ea_pca9532</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>ea_touch_demo</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>ea_touch_demo</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>ea_xbee</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>ea_xbee</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
      <member>
        <project>sdram_dhry</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>sdram_dhry</project>
        <configuration>iRAM_boot_from_SPINOR</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
