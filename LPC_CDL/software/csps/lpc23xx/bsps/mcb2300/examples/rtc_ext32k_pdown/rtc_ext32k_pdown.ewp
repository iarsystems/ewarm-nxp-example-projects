# IAR project rtc_ext32k_pdown.ewp, settings and files
configuration FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\include; ..\..\..\..\..\..\lpc\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: MAPMODEFLAG=0
  OBJCOPY.OOCOutputFile: dac_ex.srec
  ILINK.IlinkOutputFile: rtc_ext32k_pdown.out
  ILINK.IlinkIcfFile: ../linker/lpc23xx_rom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: MAPMODEFLAG=1
  OBJCOPY.OOCOutputFile: adc_poll.srec
  ILINK.IlinkIcfFile: ../linker/lpc23xx_ram_iar.icf
  group (top)
    ../../startup/: crt0_iar.asm
    ../../../../lib/: lib_lpc23xx_iar.a
    ../../source/: mcb2300_init.c
    ./: rtc_ext32k_pdown.c
