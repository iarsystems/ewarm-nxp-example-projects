<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/csp_lib_project_iar/lpc23xx_csp_lib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/adc_int/adc_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/adc_poll/adc_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/dac_ex/dac_ex.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/dma_m2m/dma_m2m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/i2c_master/i2c_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/i2c_slave/i2c_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/i2c_test/i2c_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/mci_driver_test/mci_driver_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/mci_fat_test/mci_fat_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pwm_inter/pwm_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pwm_single/pwm_single.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/rtc_ext32k/rtc_ext32k.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/rtc_ext32k_pdown/rtc_ext32k_pdown.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/rtc_sysclk/rtc_sysclk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/spi_master/spi_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/spi_slave/spi_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/spi_test/spi_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ssp_self_dma/ssp_self_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ssp_self_int/ssp_self_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ssp_self_poll/ssp_self_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/timer_delay/timer_delay.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/timer_int/timer_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/uart_int/uart_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/uart_int_1/uart_int_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/uart_poll/uart_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/uart_poll_1/uart_poll_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/wdt_int/wdt_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/wdt_reset/wdt_reset.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lpc23xx_csp_lib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>adc_int</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>adc_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>adc_poll</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>adc_poll</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>dac_ex</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>dac_ex</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>dma_m2m</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>dma_m2m</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_master</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>i2c_master</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_slave</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>i2c_slave</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_test</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>i2c_test</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>mci_driver_test</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>mci_driver_test</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>mci_fat_test</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>pwm_int</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>pwm_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>pwm_single</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>pwm_single</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>rtc_ext32k</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>rtc_ext32k</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>rtc_ext32k_pdown</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>rtc_ext32k_pdown</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>rtc_sysclk</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>rtc_sysclk</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>spi_master</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>spi_master</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>spi_slave</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>spi_slave</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>spi_test</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>spi_test</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_self_dma</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>ssp_self_dma</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_self_int</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>ssp_self_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_self_poll</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>ssp_self_poll</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>timer_delay</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>timer_delay</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>timer_int</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>timer_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_int</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>uart_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_int_1</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>uart_int_1</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_poll</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>uart_poll</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_poll_1</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>uart_poll_1</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>wdt_int</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>wdt_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>wdt_reset</project>
        <configuration>FLASH</configuration>
      </member>
      <member>
        <project>wdt_reset</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
