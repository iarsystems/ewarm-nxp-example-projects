# IAR project lpc23xx_csp_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDiagSuppress: Pe550, Pe111, Pe513, Pe186, Pe167, Pe068, Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\..\..\lpc\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: lpc23xx_csp_lib.srec
  ILINK.IlinkOutputFile: lpc23xx_csp_lib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../source/: lpc23xx_adc_driver.c lpc23xx_dac_driver.c lpc23xx_dma_driver.c lpc23xx_gpio_driver.c lpc23xx_i2c_driver.c lpc23xx_mci_driver.c lpc23xx_pinsel_driver.c lpc23xx_pwm_driver.c lpc23xx_rtc_driver.c lpc23xx_scb_driver.c lpc23xx_spi_driver.c lpc23xx_ssp_driver.c lpc23xx_tc_driver.c lpc23xx_uart_driver.c lpc23xx_vic_driver.c lpc23xx_wdt_driver.c
