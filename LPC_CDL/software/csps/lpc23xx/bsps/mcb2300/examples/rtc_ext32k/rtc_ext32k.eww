<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/rtc_ext32k.ewp</path>
  </project>
  <batchBuild/>
</workspace>
