# IAR project adc_poll.ewp, settings and files
configuration FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\include; ..\..\..\..\..\..\lpc\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: MAPMODEFLAG=0
  OBJCOPY.OOCOutputFile: adc_poll.srec
  ILINK.IlinkOutputFile: adc_poll.out
  ILINK.IlinkIcfFile: ../linker/lpc23xx_rom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: MAPMODEFLAG=1
  ILINK.IlinkIcfFile: ../linker/lpc23xx_ram_iar.icf
  group (top)
    ./: adc_poll.c
    ../../startup/: crt0_iar.asm
    ../../../../lib/: lib_lpc23xx_iar.a
    ../../source/: mcb2300_init.c
