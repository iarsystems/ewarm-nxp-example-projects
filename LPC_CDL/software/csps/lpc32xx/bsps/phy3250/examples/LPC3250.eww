<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/adc/adc_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/hstimer/hstimer_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/hsuart/hsuart_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/i2c/i2c_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/kscan/kscan_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/lcd_colorbars/lcd_colorbars.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/lcd_tsc/lcd_tsc_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/mi2c/mi2c_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/mstimer/mstimer_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pwm/pwm_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pwm_simple/pwm_simple_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/rtc/rtc_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sdcard_dma/sdcard_dma_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sdcard/sdcard_no_dma_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/slc/slcnand_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/spi/spi_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ssp/ssp_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sysclock/sysclk_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/timer/timer_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/uart/uart_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/wdt/wdt_example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>adc_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>adc_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>adc_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>adc_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>hstimer_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>hstimer_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>hstimer_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>hstimer_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>hsuart_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>hsuart_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>hsuart_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>hsuart_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>i2c_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>i2c_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>i2c_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>i2c_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>kscan_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>kscan_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>kscan_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>lcd_colorbars</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>lcd_colorbars</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>lcd_colorbars</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>lcd_tsc_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>lcd_tsc_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>lcd_tsc_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>mstimer_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>mstimer_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>mstimer_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>mstimer_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>pwm_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>pwm_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>pwm_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>pwm_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>pwm_simple_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>pwm_simple_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>pwm_simple_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>pwm_simple_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>rtc_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>rtc_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>rtc_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>sdcard_dma_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>sdcard_dma_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>sdcard_dma_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>sdcard_no_dma_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>sdcard_no_dma_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>sdcard_no_dma_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>sdcard_no_dma_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>slcnand_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>slcnand_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>slcnand_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>spi_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>spi_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>spi_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>spi_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>ssp_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>ssp_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>ssp_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>ssp_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>sysclk_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>sysclk_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>sysclk_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>sysclk_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>wdt_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>wdt_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>wdt_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>wdt_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
      <member>
        <project>mi2c_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>mi2c_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>mi2c_example</project>
        <configuration>Release_xRAM_boot_from_NAND256(32M)</configuration>
      </member>
      <member>
        <project>mi2c_example</project>
        <configuration>Release_xRAM_boot_from_NAND512(64M)</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
