<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/adc/adc_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eth_poll/eth_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/fatfs/fatfs_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/i2c/i2c_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/lcd_colorbars/lcd_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/rtc/rtc_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sdcard/sdcard_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/slc_nand/slcnand_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/spi_nor/spi_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/timer/timer_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/touch_screen/touch_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/uart/uart_example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>adc_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>adc_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>adc_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>eth_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>eth_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>eth_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>fatfs_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>fatfs_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>fatfs_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>i2c_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>i2c_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>i2c_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>lcd_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>lcd_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>rtc_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>rtc_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>rtc_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>sdcard_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>sdcard_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>sdcard_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>slcnand_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>slcnand_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>slcnand_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>spi_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>spi_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>spi_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>timer_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>touch_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>touch_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>Debug_iRAM</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>Debug_xRAM</configuration>
      </member>
      <member>
        <project>uart_example</project>
        <configuration>Release_xRAM_boot_from_NAND</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
