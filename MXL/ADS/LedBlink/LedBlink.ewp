# IAR project LedBlink.ewp, settings and files
configuration xFlashDebug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MC9328MXL NXP MC9328MXL
  ICCARM.CCIncludePath2: app\; board\; module\; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: LedBlink.out
  ILINK.IlinkIcfFile: config/xFlash.icf
  group (top)
    app/: main.c
  group common
    board/: MXL_cstartup.s mxl_init.c
