# IAR project GettingStarted.ewp, settings and files
configuration SRAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX23 NXP MCIMX23
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_EXEC
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _SRAM_EXEC
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/mcimx23_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DDR Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/mcimx23_ddr.icf
  group (top)
    ./: main.c readme.txt
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group modules
    modules/: drv_icoll.c
  group Startup
    board/: low_level_init.c
