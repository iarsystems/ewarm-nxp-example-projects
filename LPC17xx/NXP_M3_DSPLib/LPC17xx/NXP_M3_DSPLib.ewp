# IAR project NXP_M3_DSPLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: NXP_M3_DSPLib.out
  group (top)
    ./: cr_dsplib.h cr_dsplib_biquad32.s cr_dsplib_blockfir32.s cr_dsplib_dotproduct.s cr_dsplib_fft1024.s cr_dsplib_fft256.s cr_dsplib_fft64.s cr_dsplib_pid.s cr_dsplib_random.s cr_dsplib_resonator.s cr_dsplib_vectoradd.s cr_dsplib_vectoraddconst.s cr_dsplib_vectormulconst.s cr_dsplib_vectormulelement.s cr_dsplib_vectorsub.s cr_dsplib_vectsumofsquares.s
