# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1766 NXP LPC1766
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: KEIL_MCB2300
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SRAM
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/LPC1766_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/LPC1766_Flash.icf
  group (top)
    ./: cstartup_M.s main.c readme.txt
