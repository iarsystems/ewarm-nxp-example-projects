<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/NOKIA6610_LCD/EWARM/lcd_nokia6610.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QVGA_TFT_LCD/EWARM/lcd_qvga_tft.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lcd_nokia6610</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>lcd_qvga_tft</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>lcd_qvga_tft</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
