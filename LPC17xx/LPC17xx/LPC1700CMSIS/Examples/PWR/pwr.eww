<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/EXTINT_Sleep/EWARM/pwr_extint_sleep.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/NMI_PowerDown/EWARM/pwr_nmi_powerdown.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_DeepPWD/EWARM/pwr_rtc_deeppwd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/WDT_DeepSleep/EWARM/pwr_wdt_deepsleep.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>pwr_extint_sleep</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>pwr_extint_sleep</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>pwr_nmi_powerdown</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>pwr_nmi_powerdown</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>pwr_rtc_deeppwd</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>pwr_rtc_deeppwd</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>pwr_wdt_deepsleep</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>pwr_wdt_deepsleep</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
