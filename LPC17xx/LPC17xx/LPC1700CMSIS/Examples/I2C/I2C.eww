<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/master/EWARM/i2c_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Monitor/EWARM/i2c_monitor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Master_Slave_Interrupt/EWARM/i2c_msint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pca8581_polling/EWARM/i2c_pca8581.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sc16is750_int/EWARM/i2c_sc16is750_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sc16is750_polling/EWARM/i2c_sc16is750_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/slave/EWARM/i2c_slave.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>i2c_sc16is750_int</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2c_sc16is750_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_master</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2c_master</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_monitor</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2c_monitor</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_msint</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2c_msint</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_pca8581</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2c_pca8581</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_sc16is750_poll</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2c_sc16is750_poll</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2c_slave</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2c_slave</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
