<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Burst/EWARM/adc_burst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA/EWARM/adc_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HardwareTrigger/EWARM/adc_hardware_trigger_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/INTERRUPT/EWARM/adc_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Polling/EWARM/adc_polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>adc_dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>adc_dma</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>adc_int</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>adc_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>adc_polling</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>adc_polling</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>adc_burst</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>adc_burst</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>adc_hardware_trigger_test</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>adc_hardware_trigger_test</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
