<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CAN_test_bypass_mode/EWARM/can_bypass.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CAN_LedControl/EWARM/can_ledcontrol.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CAN_self_test/EWARM/can_self_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CAN_test_AFLUT/EWARM/can_test_aflut.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CAN_test_two_kit/EWARM/can_twokit.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>can_bypass</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>can_bypass</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>can_twokit</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>can_twokit</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>can_self_test</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>can_self_test</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>can_ledcontrol</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>can_ledcontrol</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>can_test_aflut</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>can_test_aflut</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
