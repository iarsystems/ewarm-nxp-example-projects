<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LoopBack/EWARM/spi_loopback.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Master/EWARM/spi_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sc16is750_int/EWARM/spi_sc16is750_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sc16is750_polling/EWARM/spi_sc16is750_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDCard/EWARM/spi_sdcard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Slave/EWARM/spi_slave.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>spi_loopback</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>spi_loopback</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>spi_master</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>spi_master</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>spi_slave</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>spi_slave</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>spi_sc16is750_int</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>spi_sc16is750_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>spi_sc16is750_poll</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>spi_sc16is750_poll</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>spi_sdcard</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>spi_sdcard</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
