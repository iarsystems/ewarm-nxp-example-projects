# IAR project emac_easyweb.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=0; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCDiagSuppress: Pa050, Pa082,
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC17xx\Include; ..\..\..\..\Core\Device\NXP\LPC17xx\Source\Templates\IAR; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: easyweb.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../makesection/makerule/common/ldscript_irom_iar.ld
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC17xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_emac.c lpc17xx_pinsel.c lpc17xx_uart.c
  group Main
    ../: ADC.c easyweb.c EMAC.c Retarget.c tcpip.c
  group Readme
    ../: Abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC17xx/Source/Templates/IAR/: startup_LPC17xx.s
