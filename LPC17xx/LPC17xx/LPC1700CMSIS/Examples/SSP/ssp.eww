<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/dma/EWARM/ssp_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Master/EWARM/ssp_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MicroWire/EWARM/ssp_microwire.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sc16is750_int/EWARM/ssp_sc16is750_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/sc16is750_polling/EWARM/ssp_sc16is750_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Slave/EWARM/ssp_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TI/EWARM/ssp_ti.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ssp_dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>ssp_dma</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_master</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>ssp_master</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_microwire</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>ssp_microwire</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_sc16is750_int</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>ssp_sc16is750_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_sc16is750_poll</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>ssp_sc16is750_poll</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_slave</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>ssp_slave</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>ssp_ti</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>ssp_ti</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
