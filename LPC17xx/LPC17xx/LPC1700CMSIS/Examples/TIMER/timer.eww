<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Capture/EWARM/timer_capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FreqMeasure/EWARM/timer_freqmeasure.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Gen_Diff_Delay/EWARM/timer_gen_diff_delay.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Gen_Diff_Freqs/EWARM/timer_gen_diff_freqs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Interrupt_Match/EWARM/timer_match_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Polling_Match/EWARM/timer_poll_match.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWMSignal/EWARM/timer_pwmsignal.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>timer_capture</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>timer_capture</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>timer_freqmeasure</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>timer_freqmeasure</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>timer_gen_diff_delay</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>timer_gen_diff_delay</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>timer_gen_diff_freqs</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>timer_gen_diff_freqs</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>timer_match_int</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>timer_match_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>timer_poll_match</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>timer_poll_match</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>timer_pwmsignal</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>timer_pwmsignal</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
