# IAR project Accelerometer.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1768_SK; FLASH_LPC1768
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD_Demo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1768_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s readme.txt
    app/: main.c
  group Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Modules
    modules/: drv_glcd.c drv_glcd_cnfg.h glcd_ll.c i2c_drv.c smb380_drv.c
  group Pictures
    app/: iar_logo.c
