# IAR project FlashNVol.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: LPC17XX
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; modules\; ..\..\LPC1700CMSIS\Core\Device\NXP\LPC17xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashNVol.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: flash_nvol.c main_lpc17xx.c readme.txt
    app/: iar_logo.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group CMSIS
    ../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/IAR/: startup_LPC17xx.s
    ../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC17xx.c
  group modules
    modules/: drv_glcd.c glcd_ll.c
