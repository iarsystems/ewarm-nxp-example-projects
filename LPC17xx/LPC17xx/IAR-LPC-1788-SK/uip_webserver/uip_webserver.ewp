# IAR project uip_webserver.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1788_SK
  ICCARM.CCIncludePath2: ; app\; board\; modules\; uip\; uip\httpd\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uip_webserver.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1788_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_1788_SK; SDRAM_DEBUG
  AARM.ADefines: SDRAM_DEBUG
  ILINK.IlinkIcfFile: config/LPC1788_SDRAM.icf
  group (top)
    ./: readme.txt vectors.s
  group app
    app/: clock-arch.c main.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group modules
    modules/: drv_clk.c drv_glcd.c drv_nvic.c LPC17xx_enet.c sdram_64M_32bit_drv.c
  group Pictures
    app/: iar_logo.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
