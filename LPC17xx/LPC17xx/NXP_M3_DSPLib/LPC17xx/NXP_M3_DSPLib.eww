<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/cr_dsplib_testbench_biquad32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/cr_dsplib_testbench_blockfir32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/cr_dsplib_testbench_fft.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/cr_dsplib_testbench_random.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/cr_dsplib_testbench_resonator.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/NXP_M3_DSPLib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>NXP_M3_DSPLib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>cr_dsplib_testbench_biquad32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>cr_dsplib_testbench_blockfir32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>cr_dsplib_testbench_fft</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>cr_dsplib_testbench_random</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>cr_dsplib_testbench_resonator</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
