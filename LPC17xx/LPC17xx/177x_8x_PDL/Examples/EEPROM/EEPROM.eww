<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Eeprom_Demo/EWARM/Eeprom_Demo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Eeprom_Demo</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Eeprom_Demo</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
