# IAR project Emac_uIP.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe068, Pe550, Pe186, Pa039, Pe144, Pe128, Pe177
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..\apps\webserver; ..\lpc177x_8x_port; ..\uIP; ..; ..\..\..\..\..\LPC1700CMSIS\Core\Device\NXP\LPC17xx\Include; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../linker/ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC177x_8x.c
  group Common
    ../common/: printf-stdarg.c Serial.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_emac.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c
    ../../../../BoardSupport/: phylan.c
  group Port
    ../lpc177x_8x_port/: clock-arch.c emac.c Emac_uIP.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/IAR/: startup_LPC177x_8x.s
  group uIP
    ../uip/: psock.c timer.c uip.c uip_arp.c
  group Webserver
    ../apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
