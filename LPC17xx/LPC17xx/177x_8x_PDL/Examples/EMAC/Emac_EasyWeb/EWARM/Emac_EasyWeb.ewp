# IAR project Emac_EasyWeb.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161, Pe223
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\..\LPC1700CMSIS\Core\Device\NXP\LPC17xx\Include; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Dma.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../linker/ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__
  AARM.ADefines: SRAM
  ILINK.IlinkIcfFile: ../../../../linker/ldscript_iram_iar.icf
  group CMSIS-CM3
    ../../../../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_clkpwr.c lpc177x_8x_emac.c lpc177x_8x_pinsel.c lpc177x_8x_timer.c lpc177x_8x_uart.c
    ../../../../BoardSupport/: phylan.c
  group Main
    ../: EMAC.c Emac_EasyWeb.c tcpip.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/IAR/: startup_LPC177x_8x.s
