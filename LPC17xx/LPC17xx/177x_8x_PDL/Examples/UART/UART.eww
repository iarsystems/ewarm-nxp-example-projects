<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UART_Autobaud/EWARM/Uart_Autobaud.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_Dma/EWARM/Uart_Dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_FullModem/EWARM/Uart_FullModem.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_Interrupt/EWARM/Uart_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_IrdaReceive/EWARM/Uart_IrdaReceive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_IrdaTransmit/EWARM/Uart_IrdaTransmit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_Polling/EWARM/Uart_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_Rs485Master/EWARM/Uart_Rs485Master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Uart_Rs485Slave/EWARM/Uart_Rs485Slave.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Uart_Autobaud</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_Autobaud</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Uart_Dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_Dma</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Uart_FullModem</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_FullModem</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Uart_Interrupt</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_Interrupt</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Uart_IrdaReceive</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_IrdaReceive</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Uart_IrdaTransmit</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_IrdaTransmit</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Uart_Polling</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_Polling</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Uart_Rs485Master</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_Rs485Master</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Uart_Rs485Slave</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Uart_Rs485Slave</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
