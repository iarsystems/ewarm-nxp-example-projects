<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Nvic_Priorities/EWARM/Nvic_Priorities.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Nvic_VectorTableRelocation/EWARM/Nvic_VectorTableRelocation.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Nvic_Priorities</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Nvic_Priorities</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Nvic_VectorTableRelocation</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Nvic_VectorTableRelocation</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
