<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Qei_Velo/EWARM/Qei_Velo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Qei_Velo</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Qei_Velo</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
