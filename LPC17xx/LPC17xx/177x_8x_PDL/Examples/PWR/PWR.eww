<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Pwr_DeepPowerDown/EWARM/Pwr_DeepPowerDown.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_DeepSleep/EWARM/Pwr_DeepSleep.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Pwr_PowerDown/EWARM/Pwr_PowerDown.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_Sleep/EWARM/Pwr_Sleep.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Pwr_DeepPowerDown</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Pwr_DeepSleep</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Pwr_DeepSleep</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Pwr_PowerDown</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Pwr_PowerDown</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Pwr_Sleep</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Pwr_Sleep</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
