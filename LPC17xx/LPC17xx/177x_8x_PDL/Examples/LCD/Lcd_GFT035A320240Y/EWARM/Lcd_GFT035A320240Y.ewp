# IAR project Lcd_GFT035A320240Y.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..\app; ..\modules; ..\board; ..\..\..\..\Drivers\include; ..; ..\..\..\..\..\LPC1700CMSIS\Core\Device\NXP\LPC17xx\Include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lcd_GFT035A320240Y.srec
  ILINK.IlinkOutputFile: LCD_Demo.out
  ILINK.IlinkIcfFile: ../../../../linker/ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/: Cursor.c logo.c main.c
  group CMSIS-CM3
    ../../../../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../modules/: drv_glcd.c i2c1_drv.c smb380_drv.c
    ../../../../Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_pinsel.c
    ../../../../BoardSupport/: sdram_k4s561632j.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/IAR/: startup_LPC177x_8x.s
