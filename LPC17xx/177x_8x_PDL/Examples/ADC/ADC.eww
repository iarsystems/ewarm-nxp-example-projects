<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Adc_Burst/EWARM/Adc_Burst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_Dma/EWARM/Adc_Dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_Interrupt/EWARM/Adc_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_Polling/EWARM/Adc_Polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Adc_Burst</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Adc_Burst</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Adc_Dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Adc_Dma</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Adc_Interrupt</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Adc_Interrupt</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Adc_Polling</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Adc_Polling</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
