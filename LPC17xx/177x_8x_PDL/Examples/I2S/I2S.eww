<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2s_4Wire/EWARM/I2s_4Wire.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2s_Audio/EWARM/I2s_Audio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2s_Dma/EWARM/I2s_Dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2s_Interrupt/EWARM/I2s_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2s_Mclk/EWARM/I2s_Mclk.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>I2s_4Wire</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>I2s_4Wire</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>I2s_Audio</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>I2s_Dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>I2s_Dma</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>I2s_Interrupt</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>I2s_Interrupt</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>I2s_Mclk</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>I2s_Mclk</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
