# IAR project I2s_Audio.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\..\LPC1700CMSIS\Core\Device\NXP\LPC17xx\Include; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Dma.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../linker/ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c
    ../../../../BoardSupport/: uda1380.c
  group Main
    ../: audiodata.c I2s_Audio.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../../LPC1700CMSIS/Core/Device/NXP/LPC17xx/Source/Templates/IAR/: startup_LPC177x_8x.s
