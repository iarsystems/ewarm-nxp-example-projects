<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Crc_Demo/EWARM/Crc_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Crc_Dma/EWARM/Crc_Dma.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Crc_Demo</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Crc_Demo</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Crc_Dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Crc_Dma</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
