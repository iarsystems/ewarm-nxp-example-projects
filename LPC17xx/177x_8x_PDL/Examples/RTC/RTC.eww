<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Rtc_Alarm/EWARM/Rtc_Alarm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Rtc_Calibration/EWARM/Rtc_Calibration.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Rtc_Alarm</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Rtc_Alarm</project>
        <configuration>Ram</configuration>
      </member>
      <member>
        <project>Rtc_Calibration</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>Rtc_Calibration</project>
        <configuration>Ram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
