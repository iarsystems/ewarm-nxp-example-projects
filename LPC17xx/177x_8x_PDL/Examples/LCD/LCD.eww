<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Lcd_GFT035A320240Y/EWARM/Lcd_GFT035A320240Y.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Lcd_GFT035A320240Y</project>
        <configuration>Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
