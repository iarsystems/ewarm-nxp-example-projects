# IAR project arm_graphic_equalizer_example.ewp, settings and files
configuration Cortex_M3 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM3
  ICCARM.CCDiagSuppress: Pa093
  ICCARM.CCIncludePath2: ..\..\Source\Common\Include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Cortex_M4 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ARM_MATH_CM4
  group (top)
    src/: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
    ../../Source/Common/Source/: math_helper.c
