# IAR project MassStorage.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1768_SK; FLASH_LPC1768
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MassStorage.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1768_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s readme.txt
    app/: main.c
  group Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Luns
    app/: lun.c
  group Luns/SD/MMC
    app/: sd_dsk_desc.c sd_spi_mode.c
  group Modules
    modules/: drv_glcd.c drv_glcd_cnfg.h glcd_ll.c
    app/: sd_ll_spi1.c
  group Pictures
    app/: iar_logo.c
  group USB/Class
    app/: scsi.c scsi_ll.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
