# IAR project USB_HostDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1768_SK; FLASH_LPC1768; PRINT_ENABLE
  ICCARM.CCIncludePath2: app; board; modules; host\Host; host\Include; host\fat; host\MassStorage
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_HostDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1768_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s readme.txt
  group app
    app/: main.c
  group app/Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group app/Pictures
    app/: iar_logo.c
  group board
    board/: sys.c
  group board/config
    config/: LPC1768_Flash.icf
  group Host/Classes/MassStorage
    Host/MassStorage/: usbhost_ms.c
  group Host/Classes/MassStorage/Fat
    Host/Fat/: io_cache.c usbhost_fat.c
  group Host/Core
    Host/Host/: usbhost_lpc2468.c
  group Modules
    modules/: drv_glcd.c glcd_ll.c
