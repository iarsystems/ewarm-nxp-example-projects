# IAR project Bootloader.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1768_BootFlash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: comms.c sbl_config.h sbl_main.c
  group board_init
    board_init/: board_init.c
  group Debug
    Debug/: uart.c
  group ethernet
    ethernet/: emac.c
  group isp
    isp/: isp_iap.c
  group startup
    startup/: cstartup_M.s
  group timer
    timer/: timer.c
