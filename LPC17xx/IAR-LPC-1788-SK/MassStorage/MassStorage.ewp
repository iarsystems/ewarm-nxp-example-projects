# IAR project MassStorage.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1788_SK
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MassStorage.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1788_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_1788_SK; SDRAM_DEBUG
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: SDRAM_DEBUG
  ILINK.IlinkIcfFile: config/LPC1788_SDRAM.icf
  group (top)
    ./: readme.txt vectors.s
  group app
    app/: main.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group LUNs
    app/: lun.c
  group LUNs/SD/MMC
    app/: sd_card_mode.c
  group modules
    modules/: drv_clk.c drv_glcd.c drv_nvic.c sdram_64M_32bit_drv.c
  group Pictures
    app/: iar_logo.c
  group USB/Class
    app/: scsi.c scsi_ll.c sd_dsk_desc.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
