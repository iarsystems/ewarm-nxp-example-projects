<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USB_Host.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_Host</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>USB_Host</project>
        <configuration>SDRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
