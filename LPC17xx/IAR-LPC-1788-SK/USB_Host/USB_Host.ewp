# IAR project USB_Host.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1788_SK
  ICCARM.CCIncludePath2: ; app\; board\; modules\; host\Host\; host\Include\; host\fat\; host\MassStorage\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_Host.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1788_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_1788_SK; SDRAM_DEBUG
  AARM.ADefines: SDRAM_DEBUG
  ILINK.IlinkIcfFile: config/LPC1788_SDRAM.icf
  group (top)
    ./: vectors.s
  group app
    app/: main.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Host/Classes/MassStorage
    Host/MassStorage/: usbhost_ms.c
  group Host/Classes/MassStorage/Fat
    Host/Fat/: io_cache.c usbhost_fat.c
  group Host/Core
    Host/Host/: usbhost_lpc178x.c
  group modules
    modules/: drv_clk.c drv_glcd.c drv_nvic.c sdram_64M_32bit_drv.c
  group Pictures
    app/: iar_logo.c
