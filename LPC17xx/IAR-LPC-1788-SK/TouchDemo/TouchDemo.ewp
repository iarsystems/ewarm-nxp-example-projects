# IAR project TouchDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1788_SK
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TouchDemo.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1788_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_1788_SK; SDRAM_DEBUG
  AARM.ADefines: SDRAM_DEBUG
  ILINK.IlinkIcfFile: config/LPC1788_SDRAM.icf
  group (top)
    ./: readme.txt vectors.s
  group app
    app/: main.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group modules
    modules/: drv_clk.c drv_glcd.c drv_nvic.c drv_touch_scr.c sdram_64M_32bit_drv.c
  group Pictures
    app/: cursor_arrow.c iar_logo.c
