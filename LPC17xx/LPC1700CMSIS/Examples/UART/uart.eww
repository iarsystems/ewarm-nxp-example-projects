<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/IrDA/Receive/EWARM/uar_irda_receive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART1_FullModem/EWARM/uart1_modem.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/AutoBaud/EWARM/uart_autobaud.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA/EWARM/uart_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HWFlowControl/EWARM/uart_hw_flow_control.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Interrupt/EWARM/uart_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/IrDA/Transmit/EWARM/uart_irda_transmit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Polling/EWARM/uart_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RS485_Master/EWARM/uart_rs485_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RS485_Slave/EWARM/uart_rs485_slave.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>uart_autobaud</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart_autobaud</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart_dma</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_int</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_polling</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart_polling</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uar_irda_receive</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uar_irda_receive</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_hw_flow_control</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart_hw_flow_control</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_irda_transmit</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart_irda_transmit</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_rs485_master</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart_rs485_master</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart_rs485_slave</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart_rs485_slave</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>uart1_modem</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>uart1_modem</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
