<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Flash_2_Ram_Test/EWARM/gpdma_flash2ram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Link_list/EWARM/gpdma_linklist.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Ram_2_Ram_Test/EWARM/gpdma_ram2ram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/GPDMA_Sleep/EWARM/gpdma_sleep.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>gpdma_flash2ram</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>gpdma_flash2ram</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>gpdma_linklist</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>gpdma_linklist</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>gpdma_ram2ram</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>gpdma_ram2ram</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>gpdma_sleep</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>gpdma_sleep</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
