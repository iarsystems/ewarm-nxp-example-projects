<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USBAudio/EWARM/usbdev_audio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USBCDC/EWARM/usbdev_cdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USBHID/EWARM/usbdev_hid.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USBMassStorage/EWARM/usbdev_mass_storage.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>usbdev_audio</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>usbdev_audio</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>usbdev_cdc</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>usbdev_cdc</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>usbdev_hid</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>usbdev_hid</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>usbdev_mass_storage</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>usbdev_mass_storage</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
