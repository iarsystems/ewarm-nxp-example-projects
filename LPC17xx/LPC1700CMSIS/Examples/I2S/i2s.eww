<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2S_test_4_wire/EWARM/i2s_4wire.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2S_DMA/EWARM/i2s_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2S_IRQ/EWARM/i2s_irq.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2S_MCLK/EWARM/i2s_mclk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Polling/EWARM/i2s_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2S_two_kit/EWARM/i2s_twokit.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>i2s_dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2s_dma</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2s_irq</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2s_irq</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2s_poll</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2s_poll</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2s_twokit</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2s_twokit</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2s_4wire</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2s_4wire</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>i2s_mclk</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>i2s_mclk</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
