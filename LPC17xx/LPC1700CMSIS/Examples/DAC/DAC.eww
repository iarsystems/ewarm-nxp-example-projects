<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DMA/EWARM/dac_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SineWave/EWARM/dac_sinewave_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Speaker/EWARM/dac_speaker.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/WaveGenerate/EWARM/dac_wavegenerate.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>dac_dma</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>dac_dma</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>dac_sinewave_test</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>dac_sinewave_test</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>dac_speaker</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>dac_speaker</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>dac_wavegenerate</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>dac_wavegenerate</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
