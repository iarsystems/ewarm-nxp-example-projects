<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USBAudioMicroPhone/EWARM/USBAudioMicroPhone.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USBAudioMicroPhone</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>USBAudioMicroPhone</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
