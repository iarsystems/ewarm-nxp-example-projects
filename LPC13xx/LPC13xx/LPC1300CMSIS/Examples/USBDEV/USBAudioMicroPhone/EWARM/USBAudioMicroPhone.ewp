# IAR project USBAudioMicroPhone.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=0
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\Device\NXP\LPC13xx\Include\; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../makesection/makerule/common/ldscript_irom_iar.ld
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../makesection/makerule/common/ldscript_iram_iar.ld
  group (top)
    ../doc/: Abstract.txt
  group CMSIS-CM3
    ../../../../Device/NXP/LPC13xx/Source/: system_LPC13xx.c
  group Drivers
    ../../../../Drivers/source/: lpc13xx_adc.c lpc13xx_clkpwr.c lpc13xx_gpio.c lpc13xx_i2c.c lpc13xx_nvic.c lpc13xx_pinsel.c lpc13xx_ssp.c lpc13xx_timer.c lpc13xx_uart.c lpc13xx_wdt.c
  group Main
    ../: adcuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c
  group Startup
    ../../../../Device/NXP/LPC13xx/Source/IAR/: startup_LPC13xx.s
