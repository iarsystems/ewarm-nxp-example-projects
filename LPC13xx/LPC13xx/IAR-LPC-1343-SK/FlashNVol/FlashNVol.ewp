# IAR project FlashNVol.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: LPC13XX
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; modules\; ..\..\LPC1300CMSIS\Device\NXP\LPC13xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashNVol.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: flash_nvol.c main_lpc13xx.c readme.txt
  group CMSIS
    ../../LPC1300CMSIS/Device/NXP/LPC13xx/Source/IAR/: startup_LPC13xx.s
    ../../LPC1300CMSIS/Device/NXP/LPC13xx/Source/: system_LPC13xx.c
  group modules
    modules/: drv_hd44780.c drv_hd44780_l.c
