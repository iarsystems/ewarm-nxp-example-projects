<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/INTERRUPT/EWARM/adc_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Polling/EWARM/adc_polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>adc_int</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>adc_int</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>adc_polling</project>
        <configuration>Flash</configuration>
      </member>
      <member>
        <project>adc_polling</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
