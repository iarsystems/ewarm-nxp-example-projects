# IAR project GettingStarted.ewp, settings and files
configuration VRAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MCIMX27 NXP MCIMX27
  ICCARM.CCDefines: VRAM_EXEC
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/mcimx27_vram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DDRRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DDRRAM_EXEC; MMU_ENA
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: config/mcimx27_ddrram.icf
configuration NOR Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX27_Lite NXP MCIMX27_Lite
  ICCARM.CCDefines: MMU_ENA
  ILINK.IlinkIcfFile: config/mcimx27_nor.icf
configuration NAND Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX27_Lite NXP MCIMX27_Lite
  ICCARM.CCDefines: MMU_ENA
  ILINK.IlinkIcfFile: config/mcimx27_nand2ddrram.icf
  group (top)
    modules/: drv_aitc.c
    ./: main.c readme.txt
  group Bootloader
    board/: nand_bootloader.c nand_MX27_cstartup.s
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Startup
    board/: low_level_init.c MX27_cstartup.s
