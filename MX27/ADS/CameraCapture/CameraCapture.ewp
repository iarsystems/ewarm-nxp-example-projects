# IAR project CameraCapture.ewp, settings and files
configuration NOR Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MCIMX27_ADS NXP MCIMX27_ADS
  ICCARM.CCDefines: NOR_EXEC; MMU_ENA
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: RUN_FROM_xRAM
  ILINK.IlinkOutputFile: CameraCapture.out
  ILINK.IlinkIcfFile: config/mcimx27_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c menu_bmp.c
    ./: readme.txt
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group modules
    modules/: drv_aitc.c drv_buzzer.c drv_csi.c drv_i2c1.c drv_lcd.c drv_touch_scr.c
  group Startup
    board/: low_level_init.c MX27_cstartup.s
