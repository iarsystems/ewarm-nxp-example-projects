# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: MC13260_EVK NXP MC13260_EVK
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_EXEC
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _SRAM_EXEC
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/mc13260.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SerialFlash Debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: GettingStarted.hex
  group (top)
    ./: main.c readme.txt
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Modules
    modules/: drv_asic.c
  group Startup
    board/: low_level_init.c MC13260_cstartup.s
