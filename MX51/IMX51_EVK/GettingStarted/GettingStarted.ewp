# IAR project GettingStarted.ewp, settings and files
configuration DDR_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX51_EVK NXP MCIMX51_EVK
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: DDR_DEBUG
  ICCARM.CCIncludePath2: board\; modules\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c readme.txt
  group board
    board/: low_level_init.c ttbl.c
  group modules
    modules/: armv7a_cp15_drv.c
