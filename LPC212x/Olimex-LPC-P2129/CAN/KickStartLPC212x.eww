<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/KickStartLPC212x.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>KickStartLPC212x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>KickStartLPC212x</project>
        <configuration>RealLinkDebug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
