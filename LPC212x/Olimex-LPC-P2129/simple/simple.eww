<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/simple.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>simple</project>
        <configuration>FLASH VIA JLINK</configuration>
      </member>
      <member>
        <project>simple</project>
        <configuration>SRAM VIA JLINK</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
