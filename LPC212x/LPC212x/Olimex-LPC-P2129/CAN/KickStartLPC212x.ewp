# IAR project KickStartLPC212x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2129 Philips LPC2129
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: JTAG_DEBUG
  ICCARM.CCIncludePath2: vssrc; vsapi
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __THUMB_LIBRARY__=1
  ILINK.IlinkOutputFile: KickStartLPC212x.out
  ILINK.IlinkIcfFile: Program_in_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RealLinkDebug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VS_IS_EXPERT=0
  group src
    ./: ew_can.c usercode.c
