# IAR project simple.ewp, settings and files
configuration FLASH VIA JLINK (ARM, debug)
  General.OGChipSelectEditMenu: LPC2129 NXP LPC2129
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: simple.out
  ILINK.IlinkIcfFile: Program_in_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM VIA JLINK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_VIA_JLINK
  ILINK.IlinkIcfFile: Program_in_SRAM.icf
  group (top)
    ./: hardware.c main.c
