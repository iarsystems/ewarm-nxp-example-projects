# IAR project LPC2129_butt_led.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2129 Philips LPC2129
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: Modules\; App\; Board\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LPC2129_butt_led.out
  ILINK.IlinkIcfFile: config/Program_in_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    App/: buttons.c led.c main.c
  group Module
    Modules/: lpc_sysctrl.c lpc_timer.c lpc_vic.c
