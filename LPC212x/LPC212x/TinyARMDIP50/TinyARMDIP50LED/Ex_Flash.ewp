# IAR project Ex_Flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2129 NXP LPC2129
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EXEC_FLASH
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ARM_LIBRARY__=1
  ILINK.IlinkOutputFile: Ex_Flash.out
  ILINK.IlinkIcfFile: Tiny212x_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Ex_Flash.hex
  group (top)
    ./: Lpc212x.c main.c timer.c
