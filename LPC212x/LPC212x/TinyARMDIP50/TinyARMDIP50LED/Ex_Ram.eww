<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Ex_Ram.ewp</path>
  </project>
</workspace>


