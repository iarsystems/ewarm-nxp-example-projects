# IAR project uip_webserver.ewp, settings and files
configuration FlashDebug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2129 Philips LPC2129
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pe177,Pa082
  ICCARM.CCIncludePath2: ; app; board; modules; uip; uip\httpd
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uip_webserver.out
  ILINK.IlinkIcfFile: CONFIG/Program_in_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    uip/: uipopt.h
  group App
    app/: clock-arch.c main.c
  group Module
    modules/: cs8900a.c lpc_sysctrl.c lpc_vic.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
