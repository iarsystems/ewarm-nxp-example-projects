# IAR project Lissajous.ewp, settings and files
configuration Debug iRAM VFP9-S (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: LPC3180 Philips LPC3180
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: Lissajous.out
  ILINK.IlinkIcfFile: LPC3000_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iRAM (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: main.c
  group Startup
    ./: cstartup.s
