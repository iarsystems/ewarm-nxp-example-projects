<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Lissajous.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Lissajous</project>
        <configuration>Debug iRAM</configuration>
      </member>
      <member>
        <project>Lissajous</project>
        <configuration>Debug iRAM VFP9-S</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
