# IAR project Gettingstarted.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC3180 NXP LPC3180
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCIncludePath2: ; board\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Gettingstarted.out
  ILINK.IlinkIcfFile: config/LPC3000_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug xRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
configuration Release iRAM boot from NAND256 (ARM)
  as the first configuration, except:
configuration Release xRAM boot from NAND256 (ARM)
  as the first configuration, except:
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
configuration Release iRAM boot level 2 from NAND256 (ARM)
  as the first configuration, except:
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_iRAM_Boot_level_2.icf
configuration Release iRAM boot from NAND512 (ARM)
  as the first configuration, except:
configuration Release xRAM boot from NAND512 (ARM)
  as the first configuration, except:
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
configuration Release iRAM boot level 2 from NAND512 (ARM)
  as the first configuration, except:
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_iRAM_Boot_level_2.icf
  group (top)
    ./: main.c readme.txt
  group MMU
    board/: arm926ej_cp15_drv.c ttbl.c
  group Startup
    board/: cstartup.s
  group Startup/BOOT
    board/: nand_bootloader.c
  group Startup/iRAM
    board/: iram_init.c
