# IAR project cmsis_lpspi_edma_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MCIMX7U5DVP08; EVK_MCIMX7ULP_M4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\..\CMSIS\Core\Include; ..; ../../../../../../CMSIS/Driver/Include; ../../../../../../devices; ../../../../../../devices/MCIMX7U5_M4/drivers; ../../../../../../devices/MCIMX7U5_M4/cmsis_drivers; ../../../../../../devices/MCIMX7U5_M4/utilities; ../../../../../../devices/MCIMX7U5_M4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_lpspi_edma_transfer.out
  ILINK.IlinkIcfFile: MCIMX7U5xxx08_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX7U5DVP08; EVK_MCIMX7ULP_M4
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MCIMX7U5_M4/iar/: startup_MCIMX7U5_M4.s
    ../../../../../../devices/MCIMX7U5_M4/: system_MCIMX7U5_M4.c system_MCIMX7U5_M4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MCIMX7U5_M4/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c
    ../../../../../../devices/MCIMX7U5_M4/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group source
    ../: cmsis_lpspi_edma_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h fsl_iomuxc.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MCIMX7U5_M4/utilities/: fsl_debug_console.c fsl_debug_console.h
