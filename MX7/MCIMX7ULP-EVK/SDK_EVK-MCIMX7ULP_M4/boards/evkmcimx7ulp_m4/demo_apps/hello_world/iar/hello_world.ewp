# IAR project hello_world.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MCIMX7U5DVP08; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX7ULP_M4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../../../../devices/MCIMX7U5_M4/drivers; ../../../../../devices/MCIMX7U5_M4/utilities; ../../../../../devices/MCIMX7U5_M4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MCIMX7U5xxx08_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX7U5DVP08; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX7ULP_M4
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MCIMX7U5_M4/iar/: startup_MCIMX7U5_M4.s
    ../../../../../devices/MCIMX7U5_M4/: system_MCIMX7U5_M4.c system_MCIMX7U5_M4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MCIMX7U5_M4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_msmc.h fsl_msmc.c fsl_clock.h fsl_clock.c
  group source
    ../: hello_world.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h fsl_iomuxc.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MCIMX7U5_M4/utilities/: fsl_debug_console.c fsl_debug_console.h
