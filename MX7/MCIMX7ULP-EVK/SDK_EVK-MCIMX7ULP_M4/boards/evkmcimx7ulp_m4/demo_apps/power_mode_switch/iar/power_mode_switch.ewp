# IAR project power_mode_switch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MCIMX7U5DVP08; FSL_RTOS_FREE_RTOS; EVK_MCIMX7ULP_M4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../platform/components/wm8960; ..; ../../../../../devices; ../../../../../rtos/freertos_9.0.0/Source; ../../../../../devices/MCIMX7U5_M4/drivers; ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/include; ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/include/platform/imx7ulp_m4; ../../../../../devices/MCIMX7U5_M4/utilities; ../../../../../devices/MCIMX7U5_M4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NO_CRP
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: power_mode_switch.out
  ILINK.IlinkIcfFile: MCIMX7U5xxx08_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX7U5DVP08; FSL_RTOS_FREE_RTOS; EVK_MCIMX7ULP_M4
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NO_CRP
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group freertos/portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portasm.s portmacro.h
  group startup
    ../../../../../devices/MCIMX7U5_M4/iar/: startup_MCIMX7U5_M4.s
    ../../../../../devices/MCIMX7U5_M4/: system_MCIMX7U5_M4.c system_MCIMX7U5_M4.h
  group doc
    ../: readme.txt
  group source
    ../: low_power_tick_management.c audio_serv.c audio_serv.h fsl_srtm.c fsl_srtm.h fsl_srtm_rpmsg.c fsl_srtm_rpmsg.h keypad_serv.c keypad_serv.h lifecycle_serv.c lifecycle_serv.h pf1550_remote_serv.c pf1550_remote_serv.h pingpong.c pingpong.h FreeRTOSConfig.h rpmsg_config.h clock_scg.c main.c power_mode_switch.c power_mode_switch.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h fsl_iomuxc.h clock_config.c clock_config.h
  group drivers
    ../../../../../devices/MCIMX7U5_M4/drivers/: fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_lpi2c.c fsl_lpi2c.h fsl_mu.h fsl_mu.c fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc0.h fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_msmc.h fsl_msmc.c fsl_clock.h fsl_clock.c
  group drivers/freertos
    ../../../../../devices/MCIMX7U5_M4/drivers/: fsl_lpi2c_freertos.h fsl_lpi2c_freertos.c
  group pmic_driver
    ../: fsl_pf1550.h fsl_pf1550.c fsl_pf1550_serv.h fsl_pf1550_serv.c
  group rpmsg_lite/rpmsg_lite
    ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/include/: rpmsg_queue.h rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h compiler.h
    ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c rpmsg_lite.c rpmsg_ns.c
    ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/common/: llist.c
    ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/rpmsg_lite/env/freertos
    ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/rpmsg_lite/porting/environment/: env_freertos.c
    ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/include/: env.h
  group rpmsg_lite/porting
    ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/include/platform/imx7ulp_m4/: platform.h
    ../../../../../middleware/multicore_2.2.0/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx7ulp_m4/: platform.c
  group codec
    ../: fsl_wm8960.h fsl_wm8960.c
  group utilities
    ../../../../../devices/MCIMX7U5_M4/utilities/: fsl_debug_console.c fsl_debug_console.h
