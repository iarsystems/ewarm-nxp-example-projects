# IAR project flexio_spi_edma_lpspi_transfer_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MCIMX7U5DVP08; EVK_MCIMX7ULP_M4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../devices; ..; ../../../../../../../../devices/MCIMX7U5_M4/drivers; ../../../../../../../../devices/MCIMX7U5_M4/utilities; ../../../../../../../../devices/MCIMX7U5_M4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: flexio_spi_edma_lpspi_transfer_master.out
  ILINK.IlinkIcfFile: MCIMX7U5xxx08_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX7U5DVP08; EVK_MCIMX7ULP_M4
  ICCARM.CCIncludePath2: ../../../../../../../../devices; ..; ../../../../../..; ../../../../../../../../devices/MCIMX7U5_M4/drivers; ../../../../../../../../devices/MCIMX7U5_M4/utilities; ../../../../../../../../devices/MCIMX7U5_M4
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../../devices/MCIMX7U5_M4/iar/: startup_MCIMX7U5_M4.s
    ../../../../../../../../devices/MCIMX7U5_M4/: system_MCIMX7U5_M4.c system_MCIMX7U5_M4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MCIMX7U5_M4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_port.h fsl_clock.h fsl_clock.c fsl_flexio.c fsl_flexio.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_lpspi.c fsl_lpspi.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_msmc.h fsl_msmc.c
  group source
    ../: flexio_spi_edma_lpspi_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h fsl_iomuxc.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../../devices/MCIMX7U5_M4/utilities/: fsl_debug_console.c fsl_debug_console.h
