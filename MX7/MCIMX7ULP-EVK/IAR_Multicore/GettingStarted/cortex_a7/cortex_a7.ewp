# IAR project cortex_a7.ewp, settings and files
configuration OCRAM_STANDALONE (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_A7 NXP MCIMX7U5_A7
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX7U5_A7
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../drivers; ../drivers; ../cpu; ../cpu/headers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: cortex_a7.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OCRAM_AMP_SLAVE (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
configuration DDR_STANDALONE (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config/MCIMX7U_A7_DDR.icf
configuration DDR_AMP_SLAVE (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkIcfFile: ../config/MCIMX7U_A7_DDR.icf
  group drivers
    ../../../../drivers/: drv_gic.c
    ../drivers/: llio.c lpuart.c
  group source
    ./: cortex_a7.c
