# IAR project cortex_m4.ewp, settings and files
configuration OCRAM_STANDALONE (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7U5_M4 NXP MCIMX7U5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MCIMX7U5_M4
  ICCARM.CCIncludePath2: ../drivers; ../cpu; ../cpu/headers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: cortex_m4.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OCRAM_AMP_MULTICORE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MCIMX7U5_M4; OCRAM_AMP_MULTICORE
  ILINK.IlinkKeepSymbols: a7_app
configuration OCRAM_DDR_AMP_MULTICORE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MCIMX7U5_M4; OCRAM_DDR_AMP_MULTICORE
  ILINK.IlinkKeepSymbols: a7_app
  ILINK.IlinkIcfFile: ../config/MCIMX7U_M4_DDR.icf
  group cpu
    ../cpu/: startup_MCIMX7U5_M4.s system_MCIMX7U5_M4.c
  group drivers
    ../drivers/: llio.c lpuart.c
  group source
    ./: main.c
