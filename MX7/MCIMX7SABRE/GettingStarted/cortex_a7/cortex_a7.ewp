# IAR project cortex_a7.ewp, settings and files
configuration OCRAM_STANDALONE (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7D7_A7 NXP MCIMX7D7_A7
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCDefines: OCRAM_STANDALONE; CPU_MCIMX7D_A7
  ICCARM.CCIncludePath2: ; ..\..\..\drivers\; ..\drivers\; ..\cpu\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OCRAM_AMP_MULTICORE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: OCRAM_AMP_MULTICORE; CPU_MCIMX7D_A7
  ILINK.IlinkKeepSymbols: m4_app
configuration DDR_STANDALONE (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config/MCIMX7D_A7_DDR.icf
  group (top)
    ./: main.c
    ../: readme.txt
  group drivers
    ../../../drivers/: drv_gic.c
    ../drivers/: gpt.c llio.c uart.c
