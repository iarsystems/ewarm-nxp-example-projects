# IAR project cortex_m4.ewp, settings and files
configuration OCRAM_STANDALONE (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7D7_M4 NXP MCIMX7D7_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: OCRAM_STANDALONE; CPU_MCIMX7D_M4
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\Core\Include; ; ..\..\..\drivers\; ..\drivers\; ..\cpu\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OCRAM_AMP_SLAVE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: OCRAM_AMP_SLAVE; CPU_MCIMX7D_M4
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\Core\Include; ; ..\..\..\drivers\; ..\drivers\; ..\cpu; ..\
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  group (top)
    ./: cortex_m4.c
    ../: readme.txt
  group cpu
    ../cpu/: device_registers.h NVIC.h startup_MCIMX7D7_M4.s
  group drivers
    ../drivers/: gpt.c llio.c uart.c
