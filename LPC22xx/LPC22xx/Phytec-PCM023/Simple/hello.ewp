# IAR project hello.ewp, settings and files
configuration Internal RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC2294 NXP LPC2294
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: iRAM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: hello.out
  ILINK.IlinkIcfFile: phytec_pcm023_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Internal Flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iFLASH
  ILINK.IlinkIcfFile: phytec_pcm023_iflash.icf
configuration External RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: xRAM
  ILINK.IlinkIcfFile: phytec_pcm023_xram.icf
  group (top)
    ./: Hello.c lpc2294.c Serial.c Time.c
