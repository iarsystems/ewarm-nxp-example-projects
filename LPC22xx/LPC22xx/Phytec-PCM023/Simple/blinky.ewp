# IAR project blinky.ewp, settings and files
configuration Internal Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC2294 NXP LPC2294
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: iFLASH
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: phytec_pcm023_iflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Internal RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iRAM
  ILINK.IlinkIcfFile: phytec_pcm023_iram.icf
configuration External RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: xRAM
  ILINK.IlinkIcfFile: phytec_pcm023_xram.icf
  group (top)
    ./: Blinky.c lpc2294.c Time.c
