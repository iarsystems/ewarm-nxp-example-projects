# IAR project FreeRTOS.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: ..\Startup; FreeRTOS\include; FreeRTOS\portable; Driver\inc; Driver\src\adc; Driver\src\clock\S32K1xx; Driver\src\crc; Driver\src\interrupt; Driver\src\pins; Driver\src\wdog; Application; ..\include; Driver\CMSIS\Core\Include; Generated_Code
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Startup; FreeRTOS\include; FreeRTOS\portable; Driver\inc; Driver\src\adc; Driver\src\clock\S32K1xx; Driver\src\crc; Driver\src\interrupt; Driver\src\pins; Driver\src\wdog; Application; include
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkIcfFile: ../config/S32K144_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    Application/: main.c
  group Driver/adc
    Driver/src/adc/: adc_driver.c
  group Driver/clock
    Driver/src/clock/S32K1xx/: clock_S32K1xx.c
  group Driver/crc
    Driver/src/crc/: crc_driver.c crc_hw_access.c
  group Driver/interrrupt
    Driver/src/interrupt/: interrupt_manager.c
  group Driver/pins
    Driver/src/pins/: pins_driver.c pins_port_hw_access.c
  group Driver/wdog
    Driver/src/wdog/: wdog_driver.c wdog_hw_access.c
  group FreeRTOS/common
    FreeRTOS/common/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    FreeRTOS/portable/: heap_4.c port.c portasm.s
  group Generated_Code
    Generated_Code/: adConv1.c clockMan1.c Cpu.c crc1.c pin_mux.c watchdog1.c
  group Startup
    ../Startup/: startup_S32K144.s system_S32K144.c
