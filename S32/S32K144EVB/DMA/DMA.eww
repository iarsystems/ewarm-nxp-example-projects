<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/DMA.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>DMA</project>
                <configuration>Flash Debug</configuration>
            </member>
            <member>
                <project>DMA</project>
                <configuration>RAM Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
