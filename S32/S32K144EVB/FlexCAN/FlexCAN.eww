<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/FlexCAN.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>FlexCAN</project>
                <configuration>Flash Debug</configuration>
            </member>
            <member>
                <project>FlexCAN</project>
                <configuration>RAM Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
