# IAR project FlexCAN_FD.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: ..\Startup; ..\include; Application
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: FlexCAN_FD.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config/S32K144_ram.icf
  group Application
    Application/: FlexCAN_FD.c clocks_and_modes.c main.c
  group Startup
    ../Startup/: startup_S32K144.s system_S32K144.c
