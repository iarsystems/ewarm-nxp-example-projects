# IAR project Pgm2194_Flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2194 Philips LPC2194
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Pgm2194_Flash.out
  ILINK.IlinkIcfFile: DIP50CAN_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2194 NXP LPC2194
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Pgm2194_Flash.hex
  group (top)
    ./: Easypgm.c Editor.c Extra.c ma_gpio.c ma_i2c.c ma_pcb.c ma_spi.c ma_uart1.c Pgm24c.c Pgm25c.c
