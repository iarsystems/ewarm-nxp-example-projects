# IAR project Pgm2194_Ram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2194 Philips LPC2194
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_DEBUG
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Pgm2194_Ram.out
  ILINK.IlinkIcfFile: DIP50CAN_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Easypgm.c Editor.c Extra.c ma_gpio.c ma_i2c.c ma_pcb.c ma_spi.c ma_uart1.c Pgm24c.c Pgm25c.c
