# IAR project GettingStarted.ewp, settings and files
configuration SDRAM_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX35 NXP MCIMX35
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: SDRAM_DEBUG
  ICCARM.CCIncludePath2: board\; modules\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/mcimx35_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IRAM_DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IRAM_DEBUG
  ILINK.IlinkIcfFile: config/mcimx35_iram.icf
configuration NAND_RELEASE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX35_PDK NXP MCIMX35_PDK
  group (top)
    ./: main.c readme.txt
  group board
    board/: bootloader.c bootstartup.s ttbl.c
  group modules
    modules/: arm1136jf_cp15_drv.c drv_aitc.c
