# IAR project GettingStarted.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC3141 NXP LPC3141
  ICCARM.CCIncludePath2: $PROJ_DIR$; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC314x_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DBG_SDRAM
  AARM.ADefines: DBG_SDRAM
  ILINK.IlinkIcfFile: config/LPC314x_SDRAM.icf
configuration Debug_SPINOR_Boot_iRAM (ARM, debug)
  as the first configuration, except:
configuration Debug_SPINOR_Boot_SDRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC3152 NXP LPC3152
  ICCARM.CCDefines: DBG_SDRAM; BOOT_LEVEL_2
  AARM.ADefines: DBG_SDRAM; BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC314x_Boot_level_2.icf
  group (top)
    board/: cstartup.s vectors.s
    ./: main.c readme.txt
  group MMU
    board/: arm926ej_cp15_drv.c
  group modules
    modules/: drv_cgu.c drv_intc.c drv_spi.c drv_spinor.c
    board/: spinor_bootloader.c
