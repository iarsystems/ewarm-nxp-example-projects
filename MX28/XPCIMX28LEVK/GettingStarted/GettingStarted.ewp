# IAR project GettingStarted.ewp, settings and files
configuration DDRRAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX28 NXP MCIMX28
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: DDRRAM_EXEC; MMU_ENA
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/mcimx28_ddrram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OCRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: OCRAM_EXEC; MMU_ENA
  ILINK.IlinkIcfFile: config/mcimx28_ocram.icf
  group (top)
    ./: main.c readme.txt
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Modules
    modules/: drv_icoll.c
  group Startup
    board/: low_level_init.c MX28_cstartup.s
