<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/VirtualCom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../Img_loader/img_loader.ewp</path>
  </project>
  <batchBuild/>
</workspace>
