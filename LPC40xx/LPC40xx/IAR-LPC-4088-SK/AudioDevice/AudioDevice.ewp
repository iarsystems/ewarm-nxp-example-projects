# IAR project AudioDevice.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_4088_SK
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; ..\common\board\; ..\common\modules\; ..\common\lib\; ..\common\usb\; ..\..\LPC4000CMSIS\Device\NXP\LPC40xx\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AudioDevice.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../common/config/LPC4088_Flash.icf
  ILINK.IlinkAdditionalLibs: ..\common\lib\spifi_drv_M4.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: AudioDevice.c
  group CMSIS
    ../../LPC4000CMSIS/Device/NXP/LPC40xx/Source/IAR/: startup_LPC407x_8x.s
    ../../LPC4000CMSIS/Device/NXP/LPC40xx/Source/: system_LPC407x_8x.c
  group modules
    ../common/modules/: drv_glcd.c drv_touch_scr.c drv_vs1002.c sdram_64M_32bit_drv.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group USB/Class
    app/: audio_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    ../common/usb/: usb_buffer.c usb_t9.c
  group USB/HW
    ../common/usb/: usb_hw.c
