# IAR project img_loader.ewp, settings and files
configuration Download (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: img_loader.out
  ILINK.IlinkKeepSymbols: __img_file
  ILINK.IlinkIcfFile: config/LPC4088_img.icf
  ILINK.IlinkProgramEntryLabel: __img_file
  group (top)
    ./: empty_source.c readme.txt
    images/: SPIFIIMG.BIN
