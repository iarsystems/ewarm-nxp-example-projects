# IAR project uip_webserver.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_4088_SK
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; uip\; uip\httpd\; ..\common\board\; ..\common\modules\; ..\common\lib\; ..\..\LPC4000CMSIS\Device\NXP\LPC40xx\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uip_webserver.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../common/config/LPC4088_Flash.icf
  ILINK.IlinkAdditionalLibs: ..\common\lib\spifi_drv_M4.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: clock-arch.c uip_webserver.c
  group CMSIS
    ../../LPC4000CMSIS/Device/NXP/LPC40xx/Source/IAR/: startup_LPC407x_8x.s
    ../../LPC4000CMSIS/Device/NXP/LPC40xx/Source/: system_LPC407x_8x.c
  group modules
    ../common/modules/: drv_glcd.c LPC40xx_enet.c sdram_64M_32bit_drv.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
