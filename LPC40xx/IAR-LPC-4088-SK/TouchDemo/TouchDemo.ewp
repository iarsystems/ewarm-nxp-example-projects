# IAR project TouchDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_4088_SK
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; ..\common\board\; ..\common\modules\; ..\common\lib\; ..\..\LPC4000CMSIS\Device\NXP\LPC40xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TouchDemo.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../common/config/LPC4088_Flash.icf
  ILINK.IlinkAdditionalLibs: ..\common\lib\spifi_drv_M4.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: TouchDemo.c
  group CMSIS
    ../../LPC4000CMSIS/Device/NXP/LPC40xx/Source/IAR/: startup_LPC407x_8x.s
    ../../LPC4000CMSIS/Device/NXP/LPC40xx/Source/: system_LPC407x_8x.c
  group modules
    ../common/modules/: drv_glcd.c drv_touch_scr.c i2c_drv.c sdram_64M_32bit_drv.c smb380_drv.c
  group Pictures
    app/: cursor_arrow.c
