# IAR project USBBoot.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_4088_SK; CRP=0xFFFFFFFF; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; ..\common\board\; ..\common\modules\; ..\common\lib\; ..\common\usb\; ..\..\LPC4000CMSIS\Device\NXP\LPC40xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CRP=0xFFFFFFFF
  OBJCOPY.OOCOutputFile: USBBoot.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../common/config/LPC4088_USBBoot.icf
  ILINK.IlinkAdditionalLibs: ..\common\lib\spifi_drv_M4.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: USBBoot.c
  group CMSIS
    ../../LPC4000CMSIS/Device/NXP/LPC40xx/Source/IAR/: startup_LPC407x_8x.s
    ../../LPC4000CMSIS/Device/NXP/LPC40xx/Source/: system_LPC407x_8x.c
  group LUNs
    app/: lun.c
  group LUNs/Disk
    app/: DiskImg.c dsk_desc.c Flash.c Flash_disk.c
  group LUNs/Spifi_Disk
    app/: spifi_disk.c spifi_DiskImg.c spifi_dsk_desc.c
  group modules
    ../common/modules/: sdram_64M_32bit_drv.c
  group USB/Class
    app/: scsi.c scsi_ll.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    ../common/usb/: usb_buffer.c usb_t9.c
  group USB/HW
    ../common/usb/: usb_hw.c
