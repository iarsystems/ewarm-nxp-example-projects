# IAR project GettingStarted.ewp, settings and files
configuration DDR_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX535 NXP MCIMX535
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: SDRAM_DEBUG
  ICCARM.CCIncludePath2: board\; modules\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/mcimx535qsb_ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c readme.txt
  group board
    board/: low_level_init.c
