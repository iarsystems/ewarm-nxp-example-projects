<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/tmr.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>tmr</project>
        <configuration>Flash_Debug_2378-SK</configuration>
      </member>
      <member>
        <project>tmr</project>
        <configuration>RAM_Debug_2378-SK</configuration>
      </member>
      <member>
        <project>tmr</project>
        <configuration>Flash_Debug_P2378-SK</configuration>
      </member>
      <member>
        <project>tmr</project>
        <configuration>RAM_Debug_P2378-SK</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
