<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/dac.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>dac</project>
        <configuration>Flash_Debug_2378-SK</configuration>
      </member>
      <member>
        <project>dac</project>
        <configuration>RAM_Debug_2378-SK</configuration>
      </member>
      <member>
        <project>dac</project>
        <configuration>Flash_Debug_P2378-SK</configuration>
      </member>
      <member>
        <project>dac</project>
        <configuration>RAM_Debug_P2378-SK</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
