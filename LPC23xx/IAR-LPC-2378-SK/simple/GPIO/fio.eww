<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/fio.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>fio</project>
        <configuration>Flash_Debug_2378-SK</configuration>
      </member>
      <member>
        <project>fio</project>
        <configuration>RAM_Debug_2378-SK</configuration>
      </member>
      <member>
        <project>fio</project>
        <configuration>Flash_Debug_P2378-SK</configuration>
      </member>
      <member>
        <project>fio</project>
        <configuration>RAM_Debug_P2378-SK</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
