# IAR project extint.ewp, settings and files
configuration RAM_Debug_2378-SK (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2378_SK
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ..\common\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkOutputFile: extint.out
  ILINK.IlinkIcfFile: ../common/icf/LPC2378_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_Debug_2378-SK (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../common/icf/LPC2378_Flash.icf
  group (top)
    ../Common/src/: cstartup.s irq.c target.c
    ./: einttest.c extint.c
