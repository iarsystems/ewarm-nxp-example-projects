# IAR project AudioDevice.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2378_SK; _FIQ_USED
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: AudioDevice.out
  ILINK.IlinkIcfFile: config/lpc2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c
    ./: readme.txt
  group Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Modules
    modules/: drv_glcd.c drv_glcd_cnfg.h glcd_ll.c
    board/: sys.c
  group Pictures
    app/: iar_logo.c
  group USB/Class
    app/: audio_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
