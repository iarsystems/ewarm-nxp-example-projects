# IAR project uip_webserver.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_P2378_SK
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: app\; board\; modules\; uip; uip\httpd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uip_webserver.out
  ILINK.IlinkIcfFile: config/LPC2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: clock-arch.c main.c uip-conf.h
    ./: readme.txt
    uip/: uipopt.h
  group Board
    board/: sys.c
  group Modules
    modules/: LPC23xx_enet.c uart.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
