# IAR project emac.ewp, settings and files
configuration RAM_Debug_P2378-SK (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_P2378_SK
  ICCARM.CCDiagSuppress: Pa082, Pe111, Pe549
  ICCARM.CCIncludePath2: ..\common\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkOutputFile: emac.out
  ILINK.IlinkIcfFile: ../common/icf/lpc2378_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_Debug_P2378-SK (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../common/icf/lpc2378_flash.icf
  group (top)
    ./: crc32.c emac.c emactest.c
    ../Common/src/: cstartup.s irq.c target.c
