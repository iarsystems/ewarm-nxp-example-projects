# IAR project uart.ewp, settings and files
configuration RAM_Debug_P2378-SK (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_P2378_SK
  ICCARM.CCDiagSuppress: Pe111,Pa082
  ICCARM.CCIncludePath2: ..\common\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkIcfFile: ../common/icf/lpc2378_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_Debug_P2378-SK (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../common/icf/lpc2378_flash.icf
  group (top)
    ../Common/src/: cstartup.s irq.c target.c
    ./: uart.c uarttest.c
