# IAR project VirtualCom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2378_SK
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: VirtualCom.out
  ILINK.IlinkIcfFile: config/lpc2378_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c
    ./: readme.txt
  group Board
    board/: sys.c
  group Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Modules
    modules/: drv_glcd.c drv_glcd_cnfg.h glcd_ll.c
  group Pictures
    app/: iar_logo.c
  group UARTs
    app/: uart.c
  group USB/Class
    app/: cd_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
