# IAR project pwrman.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 Philips LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ..\common\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkOutputFile: pwrman.out
  ILINK.IlinkIcfFile: ../common/icf/LPC2300_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../common/icf/LPC2300_Flash.icf
  group (top)
    ../Common/src/: cstartup.s irq.c target.c timer.c
    ./: pmtest.c pwrman.c
