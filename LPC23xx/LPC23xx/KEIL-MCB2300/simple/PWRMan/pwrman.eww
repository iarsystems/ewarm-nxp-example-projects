<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/pwrman.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>pwrman</project>
        <configuration>Flash_Debug</configuration>
      </member>
      <member>
        <project>pwrman</project>
        <configuration>RAM_Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
