<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ssp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ssp</project>
        <configuration>Flash_Debug</configuration>
      </member>
      <member>
        <project>ssp</project>
        <configuration>RAM_Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
