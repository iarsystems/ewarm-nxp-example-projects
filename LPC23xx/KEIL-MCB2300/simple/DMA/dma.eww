<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/dma.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>dma</project>
        <configuration>Flash_Debug</configuration>
      </member>
      <member>
        <project>dma</project>
        <configuration>RAM_Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
