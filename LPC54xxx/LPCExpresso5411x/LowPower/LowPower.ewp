# IAR project LowPower.ewp, settings and files
configuration RAM_Debug_M4 (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __LPC5411X__; CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ../chip_5411x/inc; ../lpcxpresso_54114/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LowPower.srec
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: config/lpc54114jxxx_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_Debug_M0Plus (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC54114J256_M0+ NXP LPC54114J256_M0+
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS; __LPC5411X__
  AARM.ADefines: SLAVEBOOT
  group (top)
    ../chip_5411x/startup/: iar_startup_lpc5411x.s
    ./: readme.txt
  group board
    ../lpcxpresso_54114/src/: board.c board_sysinit.c
  group chip
    ../chip_5411x/src/: clock_5411x.c flexcomm_5411x.c sysinit_5411x.c uart_5411x.c
  group libs
    ../chip_5411x/libs/: iar_lib_power.a iar_lib_power_m0.a
  group src
    ./: core_main.c cvt.c deep_sleep_code.c ee_printf.c platform.c
    ../chip_5411x/src/: syscon_5411x.c
