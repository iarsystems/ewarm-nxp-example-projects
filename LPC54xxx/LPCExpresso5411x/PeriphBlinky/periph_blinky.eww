<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../lib_chip_5411x/lib_chip_5411x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../lib_board_lpcxpresso_54114/lib_board_lpcxpresso_54114.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lib_board_lpcxpresso_54114</project>
        <configuration>lib_board_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>lib_chip_5411x</project>
        <configuration>lib_chip_5411x</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
