# IAR project lib_board_lpcxpresso_54114.ewp, settings and files
configuration lib_board_lpcxpresso_54114 (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; $PROJ_DIR$; ..\chip_5411x\inc; ..\lpcxpresso_54114\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_lpcxpresso_54114
    ../lpcxpresso_54114/src/: board.c board_sysinit.c
