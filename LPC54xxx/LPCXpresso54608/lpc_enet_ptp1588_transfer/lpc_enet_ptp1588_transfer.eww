<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/lpc_enet_ptp1588_transfer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lpc_enet_ptp1588_transfer</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lpc_enet_ptp1588_transfer</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
