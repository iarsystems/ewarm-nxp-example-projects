<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GettingStarted.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>GettingStarted</project>
        <configuration>IRAM</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>IFLASH</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
