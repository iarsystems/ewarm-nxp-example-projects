<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/lpc_dmic_i2s_codec.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lpc_dmic_i2s_codec</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lpc_dmic_i2s_codec</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
