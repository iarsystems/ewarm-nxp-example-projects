# IAR project lpc_mmccard_fatfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512 NXP LPC54608J512
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; $PROJ_DIR$; ../board; ../LPC54608; ../LPC54608/drivers; ../LPC54608/drivers/common; ../LPC54608/utilities; ../LPC54608/utilities/debug_console; ../middleware/sdmmc_2.1.2/port/; ../middleware/sdmmc_2.1.2/inc/; ../middleware/sdmmc_2.1.2/src/; ../middleware/fatfs_0.12b/src; ../middleware/fatfs_0.12b/src/fsl_mmc_disk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkAdditionalLibs: ../LPC54608/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: $CONFIG_NAME$
  group board
    ../board/: board.c board.h
    ../LPC54608/: clock_config.c clock_config.h
    ./: pin_mux.c pin_mux.h
  group doc
    ./: readme.txt
  group drivers
    ../LPC54608/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_mcan.c fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_sdif.c fsl_usart.c fsl_usart.h
  group FATFS_Source
    ../middleware/fatfs_0.12b/src/: diskio.c diskio.h ff.c ff.h integer.h
    ../middleware/fatfs_0.12b/src/fsl_mmc_disk/: fsl_mmc_disk.c fsl_mmc_disk.h
  group sdmmc/inc
    ../middleware/sdmmc_2.1.2/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
  group sdmmc/port
    ./: event.c event.h fsl_host.c
  group sdmmc/src
    ../middleware/sdmmc_2.1.2/src/: fsl_mmc.c fsl_sd.c fsl_sdio.c fsl_sdmmc.c
  group source
    ./: fsl_mmccard_fatfs.c
  group startup
    ../LPC54608/iar/: startup_LPC54608.s
    ../LPC54608/: system_LPC54608.c system_LPC54608.h
  group utilities
    ../LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
