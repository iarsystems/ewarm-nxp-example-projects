# IAR project lpc_enet_ptp1588_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512 NXP LPC54608J512
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ENET_PTP1588FEATURE_REQUIRED; PRINTF_ADVANCED_ENABLE=1; NDEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; $PROJ_DIR$; ../board; ../LPC54608; ../LPC54608/drivers; ../LPC54608/drivers/common; ../LPC54608/utilities; ../LPC54608/utilities/debug_console
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkAdditionalLibs: ../LPC54608/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: $CONFIG_NAME$
  group board
    ../board/: board.c board.h
    ../LPC54608/: clock_config.c clock_config.h
    ./: pin_mux.c pin_mux.h
  group doc
    ./: readme.txt
  group drivers
    ../LPC54608/drivers/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_eeprom.c fsl_emc.c fsl_emc.h fsl_enet.c fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2s.c fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group PHY
    ../LPC54608/: fsl_phy.c
  group source
    ./: fsl_enet_ptp1588_transfer.c
  group startup
    ../LPC54608/iar/: startup_LPC54608.s
    ../LPC54608/: system_LPC54608.c system_LPC54608.h
  group utilities
    ../LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
