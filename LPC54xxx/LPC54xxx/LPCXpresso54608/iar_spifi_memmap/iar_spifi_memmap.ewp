# IAR project iar_spifi_memmap.ewp, settings and files
configuration Download (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512 NXP LPC54608J512
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_LPC54608J512BD208
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: img_loader.out
  ILINK.IlinkKeepSymbols: __img_file
  ILINK.IlinkIcfFile: config/iar_spifi_memmap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt spifi_memmap_main.c
    images/: SPIFIIMG.BIN
    ../LPC54608/iar/: startup_LPC54608.s
    ../LPC54608/: system_LPC54608.c
