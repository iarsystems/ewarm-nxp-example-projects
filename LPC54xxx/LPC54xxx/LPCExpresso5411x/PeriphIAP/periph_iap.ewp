# IAR project periph_iap.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54114 (ARM)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ..\chip_5411x\inc; ..\lpcxpresso_54114\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 0
  OBJCOPY.OOCOutputFile: periph_iap.bin
  ILINK.IlinkIcfFile: config/lpc54114j256NoLastSector.icf
  ILINK.IlinkOutputFile: clkout.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    src/: flashiap.c
    ../chip_5411x/startup/: iar_startup_lpc5411x.s sysinit.c
    ./: readme.txt
  group lib
    ../chip_5411x/libs/: iar_lib_power.a
    ../lib_board_lpcxpresso_54114/Exe/: lib_board_lpcxpresso_54114.a
    ../lib_chip_5411x/Exe/: lib_chip_5411x.a
