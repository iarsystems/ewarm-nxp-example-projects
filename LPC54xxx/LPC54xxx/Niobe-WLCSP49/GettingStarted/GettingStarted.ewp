# IAR project GettingStarted.ewp, settings and files
configuration IRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/LPC54xxx_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __IFLASH_MODE__
  AARM.ADefines: __IFLASH_MODE__
  group (top)
    ./: iar_startup_lpc5410x.s init.c main.c readme.txt
  group modules
    modules/: drv_nvic.c
