<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/extint_test.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>extint_test</project>
        <configuration>Debug iFlash</configuration>
      </member>
      <member>
        <project>extint_test</project>
        <configuration>Debug iRAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
