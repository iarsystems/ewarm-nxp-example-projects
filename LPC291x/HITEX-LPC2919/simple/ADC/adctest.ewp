# IAR project adctest.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: LPC2919 NXP LPC2919
  ICCARM.CCDefines: HITEX_BOARD
  ICCARM.CCIncludePath2: ; ..\common\inc; ..\common\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: REMAP_RAM
  ILINK.IlinkOutputFile: Gettingstarted.out
  ILINK.IlinkIcfFile: config/Blinky.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: adctest.srec
  ILINK.IlinkIcfFile: config/iFlash.icf
  group (top)
    ./: adc.c adctest.c mtimer.c
    ../Common/src/: target.c timer.c
  group Startup
    ../Common/src/: cstartup.s irq.c
