# IAR project GettingStarted.ewp, settings and files
configuration HyperFlash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: __FLASH__
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/MIMXRT1052xxx6A_FSPI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration QSPI Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __QSPI_FLASH__
configuration RAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM__
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __SDRAM__
  ILINK.IlinkIcfFile: config/MIMXRT1052xxx6A_sdram.icf
  group (top)
    ./: main.c
  group boot
    boot/: flexspi_boot.c
  group Startup
    Startup/: cstartup_M.s low_level_init.c vector_table_IMXRT1052.s
