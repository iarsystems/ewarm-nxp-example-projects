<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/GettingStarted.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>GettingStarted</project>
                <configuration>HyperFlash Debug</configuration>
            </member>
            <member>
                <project>GettingStarted</project>
                <configuration>QSPI Flash Debug</configuration>
            </member>
            <member>
                <project>GettingStarted</project>
                <configuration>RAM Debug</configuration>
            </member>
            <member>
                <project>GettingStarted</project>
                <configuration>SDRAM Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
