<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ledblink.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ledblink</project>
        <configuration>xRamDebug</configuration>
      </member>
      <member>
        <project>ledblink</project>
        <configuration>NOR Flash Debug</configuration>
      </member>
      <member>
        <project>ledblink</project>
        <configuration>Release SDRAM Boot from NAND</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
