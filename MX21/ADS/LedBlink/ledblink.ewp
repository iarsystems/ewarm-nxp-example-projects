# IAR project ledblink.ewp, settings and files
configuration xRamDebug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MC9328MX21 NXP MC9328MX21
  ICCARM.CCDefines: SDRAM_EXEC; MMU_ENA
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: RUN_FROM_xRAM
  ILINK.IlinkOutputFile: ledblink.out
  ILINK.IlinkIcfFile: config/xRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NOR Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX21_ADS NXP MCIMX21_ADS
  ICCARM.CCDefines: MMU_ENA
  ILINK.IlinkIcfFile: config/xFlash.icf
configuration Release SDRAM Boot from NAND (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX21_ADS NXP MCIMX21_ADS
  ICCARM.CCDefines: MMU_ENA
  ICCARM.CCOptLevel: 3
  group (top)
    modules/: drv_aitc.c
    app/: main.c
    ./: readme.txt
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Startup
    board/: low_level_init.c MX21_cstartup.s
  group Startup/Bootloader
    board/: bootloader.c bootstartup.s
