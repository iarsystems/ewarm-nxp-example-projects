<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CameraCapture.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CameraCapture</project>
        <configuration>xFlashDebug</configuration>
      </member>
      <member>
        <project>CameraCapture</project>
        <configuration>xRamDebug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
