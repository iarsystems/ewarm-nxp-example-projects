# IAR project 2103_FIQIntIRQ_Ex.ewp, settings and files
configuration JLINK_RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 Philips LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Common_Files\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkOutputFile: 2103_FIQIntIRQ_Ex.out
  ILINK.IlinkIcfFile: ../../Common_Files/LPC2103_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration JLINK_Flash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../Common_Files/LPC2103_Flash.icf
  group Application
    ../Source_Code/: Fiq_Int_IrQ_Ex.c
  group ARM7 Specific
    ../../Common_Files/: lpc2xxx_cstartup_Jmp2IRQ.s
  group Documentation
    ../: FIQ_Int_IRQ_Specification.txt
  group Linker Command Files
    ../../Common_Files/: LPC2103_Flash.icf LPC2103_RAM.icf
