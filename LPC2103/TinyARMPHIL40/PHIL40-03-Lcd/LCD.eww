<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/S3_Ram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/S3_Flash.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>S3_Flash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>S3_Flash</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>S3_Ram</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
