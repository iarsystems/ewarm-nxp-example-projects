<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/S1_Flash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/S1_Ram.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>S1_Flash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>S1_Flash</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>S1_Ram</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
