<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LPC2103_FIQIntIRQ/Project_Files/2103_FIQIntIRQ_Ex.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LPC2103_MultiBlink/Project_Files/2103_MultiTmr_Ex.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LPC2103_RTC_Interrupt/Project_Files/2103_RTC_Ex.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LPC2103_TMR0Int_Example/Project_Files/2103_TmrIntMR0_Ex.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>2103_FIQIntIRQ_Ex</project>
        <configuration>JLINK_Flash</configuration>
      </member>
      <member>
        <project>2103_FIQIntIRQ_Ex</project>
        <configuration>JLINK_RAM</configuration>
      </member>
      <member>
        <project>2103_MultiTmr_Ex</project>
        <configuration>JLINK_Flash</configuration>
      </member>
      <member>
        <project>2103_MultiTmr_Ex</project>
        <configuration>JLINK_RAM</configuration>
      </member>
      <member>
        <project>2103_RTC_Ex</project>
        <configuration>JLINK_Flash</configuration>
      </member>
      <member>
        <project>2103_RTC_Ex</project>
        <configuration>JLINK_RAM</configuration>
      </member>
      <member>
        <project>2103_TmrIntMR0_Ex</project>
        <configuration>JLINK_FLASH</configuration>
      </member>
      <member>
        <project>2103_TmrIntMR0_Ex</project>
        <configuration>JLINK_RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
