# IAR project Ex_Ram2103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 Philips LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_DEBUG
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ARM_LIBRARY__=1
  ILINK.IlinkOutputFile: Ex_Ram2103.out
  ILINK.IlinkIcfFile: PHIL40-03_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lpc210x.c main.c timer.c
