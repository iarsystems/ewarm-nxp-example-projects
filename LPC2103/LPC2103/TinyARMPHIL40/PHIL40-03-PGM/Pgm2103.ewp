# IAR project Pgm2103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 Philips LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Pgm2103.out
  ILINK.IlinkIcfFile: PHIL40-03_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Pgm2103.hex
  group (top)
    ./: Easypgm.c Editor.c Extra.c ma_gpio.c ma_i2c.c ma_pcb.c ma_spi.c ma_uart1.c Pgm24c.c Pgm25c.c
