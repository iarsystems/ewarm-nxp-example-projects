# IAR project S2_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 Philips LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __THUMB_LIBRARY__
  ILINK.IlinkOutputFile: S2_test.out
  ILINK.IlinkIcfFile: PHIL40-03_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: S2_test.hex
  group (top)
    ./: ma_gpio.c ma_pcb.c ma_scb.c ma_uart0.c S2_Main.c
