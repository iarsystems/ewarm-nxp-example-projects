# IAR project S3_Flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 Philips LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __THUMB_LIBRARY__
  ILINK.IlinkOutputFile: S3_Flash.out
  ILINK.IlinkIcfFile: PHIL40-03_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: S3_Flash.hex
  group (top)
    ./: Em6125.c ma_gpio.c ma_i2c.c ma_pcb.c ma_scb.c S3_lcd.c S3_Main.c
