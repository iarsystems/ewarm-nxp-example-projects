# IAR project S3_Ram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 Philips LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_DEBUG
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __THUMB_LIBRARY__
  ILINK.IlinkOutputFile: S3_Ram.out
  ILINK.IlinkIcfFile: PHIL40-03_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Em6125.c ma_gpio.c ma_i2c.c ma_pcb.c ma_scb.c S3_lcd.c S3_Main.c
