# IAR project SinePWM.ewp, settings and files
configuration FLASH_Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 NXP LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; _DLIB_ASSERT_ABORT
  ICCARM.CCIncludePath2: app; config; modules
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SinePWM.out
  ILINK.IlinkIcfFile: config/LPC2103_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: main.c usercmd.c
  group config
    config/: LPC2103_Flash.icf LPC2103_Flash.mac
  group modules
    modules/: commands.c interrupts.c PWM.c Sin_Table.c uart.c
