<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/low_power_demo_freedom.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>low_power_demo_freedom</project>
        <configuration>FLASH_128KB</configuration>
      </member>
      <member>
        <project>low_power_demo_freedom</project>
        <configuration>FLASH_32KB</configuration>
      </member>
      <member>
        <project>low_power_demo_freedom</project>
        <configuration>FLASH_64KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
