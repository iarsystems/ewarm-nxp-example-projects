<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/blinky_freedom.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>blinky_freedom</project>
        <configuration>FLASH_128KB</configuration>
      </member>
      <member>
        <project>blinky_freedom</project>
        <configuration>FLASH_32KB</configuration>
      </member>
      <member>
        <project>blinky_freedom</project>
        <configuration>FLASH_64KB</configuration>
      </member>
      <member>
        <project>blinky_freedom</project>
        <configuration>RAM_16KB</configuration>
      </member>
      <member>
        <project>blinky_freedom</project>
        <configuration>RAM_4KB</configuration>
      </member>
      <member>
        <project>blinky_freedom</project>
        <configuration>RAM_8KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
