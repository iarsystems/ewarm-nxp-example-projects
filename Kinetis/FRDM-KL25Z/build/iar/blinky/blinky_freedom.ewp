# IAR project blinky_freedom.ewp, settings and files
configuration RAM_8KB (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z64xxx4 NXP MKL25Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FREEDOM
  ICCARM.CCIncludePath2: ..\..\..\src\projects\blinky; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: blinky_freedom.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../config files/8KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_16KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  ILINK.IlinkIcfFile: ../config files/16KB_Ram.icf
configuration FLASH_128KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  ICCARM.CCDefines: IAR; FREEDOM; FLASH
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: ../config files/128KB_Pflash.icf
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; FREEDOM; FLASH
  ILINK.IlinkIcfFile: ../config files/64KB_Pflash.icf
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 NXP MKL25Z32xxx4
  ICCARM.CCDefines: IAR; FREEDOM; FLASH
  ILINK.IlinkIcfFile: ../config files/32KB_Pflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 32KB_Pflash.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: freedom.h
  group project
    ../../../src/projects/blinky/: blinky.c isr.h
