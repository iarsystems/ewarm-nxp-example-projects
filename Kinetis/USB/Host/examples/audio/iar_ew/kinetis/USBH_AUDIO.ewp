# IAR project USBH_AUDIO.ewp, settings and files
configuration Flash Debug K40 (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 NXP MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: TWR_K40X256
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\host_common; ..\..\..\..\source\classes; ..\..\..\..\source\classes\hub; ..\..\..\..\source\classes\audio
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/MK40N512VMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: TWR_K53N512
  ILINK.IlinkIcfFile: config/MK53N512CMD100_Flash.icf
  group (top)
    ./: readme.txt
  group app
    ../../: audio.c audio_data.c audio_pwm_kinetis.c kbi_kinetis.c PIT0_kinetis.c
    ../../../common/kinetis/: PIT1_kinetis.c printf.c sci.c
    ../../../common/: poll.c
  group bsp/P2
    ../../../../source/bsp/P2/: P2.c
  group class
    ../../../../source/classes/common/: usb_classes.c
  group class/audio
    ../../../../source/classes/audio/: usb_host_audio.c usb_host_audio_intf.c
  group class/hub
    ../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group driver
    ../../../../source/driver/kinetis/: khci_kinetis.c
    ../../../../source/driver/: usbevent.c usbmsgq.c usbsem.c
  group host_common
    ../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group prm
    config/: MK40N512VMD100_Flash.icf MK53N512CMD100_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
