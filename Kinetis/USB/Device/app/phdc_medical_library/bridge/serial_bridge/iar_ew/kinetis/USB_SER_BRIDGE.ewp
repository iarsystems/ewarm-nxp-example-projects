# IAR project USB_SER_BRIDGE.ewp, settings and files
configuration RAM Debug K40 (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 NXP MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K40X256
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\..\common; ..\..\..\..\..\common\kinetis; ..\..\..\..\..\common\serial; ..\..\..\..\..\..\source\driver; ..\..\..\..\..\..\source\driver\kinetis; ..\..\..\..\..\..\source\common; ..\..\..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/MK40N512VMD100_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug K40 (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/MK40N512VMD100_Flash.icf
configuration RAM Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: TWR_K53N512
  ILINK.IlinkIcfFile: config/MK53N512CMD100_RAM.icf
configuration Flash Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: TWR_K53N512
  ILINK.IlinkIcfFile: config/MK53N512CMD100_Flash.icf
  group (top)
    ./: readme.txt
  group app
    ../../: bridge_app.c usb_descriptor.c
    ../../../../../common/: main_kinetis.c
    ../../../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
  group Class
    ../../../../../common/serial/: serial_class_manager.c
    ../../../../../../source/common/: usb_class.c usb_framework.c
    ../../../../../../source/class/: usb_phdc.c
  group Driver
    ../../../../../common/serial/: serial_kinetis.c
    ../../../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../../../source/driver/: usb_driver.c
  group prm
    config/: MK40N512VMD100_Flash.icf MK40N512VMD100_RAM.icf MK53N512CMD100_Flash.icf MK53N512CMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
