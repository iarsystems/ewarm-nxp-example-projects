# IAR project USB_MSD.ewp, settings and files
configuration RAM Debug K40 (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 NXP MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K40X256
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/MK40N512VMD100_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug K40 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: USB_MSD.srec
  ILINK.IlinkIcfFile: config/MK40N512VMD100_Flash.icf
configuration RAM Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: TWR_K53N512
  ILINK.IlinkIcfFile: config/MK53N512CMD100_RAM.icf
configuration Flash Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: TWR_K53N512
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: USB_MSD.srec
  ILINK.IlinkIcfFile: config/MK53N512CMD100_Flash.icf
  group (top)
    ../../: disk.c
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../kinetis/: SD_kinetis.c SPI_kinetis.c
    ../../: usb_descriptor.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_msc.c usb_msc_scsi.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group prm
    config/: MK40N512VMD100_Flash.icf MK40N512VMD100_RAM.icf MK53N512CMD100_Flash.icf MK53N512CMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
