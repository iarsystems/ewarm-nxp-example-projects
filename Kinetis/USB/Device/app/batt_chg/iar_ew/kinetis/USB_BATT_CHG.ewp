# IAR project USB_BATT_CHG.ewp, settings and files
configuration RAM Debug K40 (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 NXP MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: TWR_K40X256
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\hid; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\usb_batt_chg; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class; ..\..\..\..\..\OTG\source\driver\max3353; ..\..\..\..\..\OTG\source\otg_common; ..\..\..\..\..\OTG\examples\common\kinetis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/MK40N512VMD100_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug K40 (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/MK40N512VMD100_Flash.icf
configuration RAM Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: TWR_K53N512
  ILINK.IlinkIcfFile: config/MK53N512CMD100_RAM.icf
configuration Flash Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: TWR_K53N512
  ILINK.IlinkIcfFile: config/MK53N512CMD100_Flash.icf
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: printf.c RealTimerCounter_kinetis.c sci.c wdt_kinetis.c
    ../../../../source/usb_batt_chg/: usb_batt_chg.c
    ../../: usb_batt_chg_app_kinetis.c
    ../../../../source/driver/: usbevent.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_hid.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group IIC
    ../../../../../OTG/examples/common/kinetis/: IIC_kinetis.c
  group MAX3353
    ../../../../../OTG/source/driver/max3353/: usb_otg_max3353_kinetis.c
  group prm
    config/: MK40N512VMD100_Flash.icf MK40N512VMD100_RAM.icf MK53N512CMD100_Flash.icf MK53N512CMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
