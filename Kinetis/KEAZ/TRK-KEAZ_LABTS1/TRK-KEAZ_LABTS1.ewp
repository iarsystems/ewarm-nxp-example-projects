# IAR project TRK-KEAZ_LABTS1.ewp, settings and files
configuration Flash Debug KEAZ128xxx4 (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: KEAZ128xxx4
  ICCARM.CCIncludePath2: Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug KEAZ64xxx4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: KEAZ64xxx4 NXP KEAZ64xxx4
  ICCARM.CCDefines: KEAZ64xxx4
configuration Flash Debug KEAZN16xxx2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: KEAZN16xxx2
configuration Flash Debug KEAZN32xxx2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: KEAZN32xxx2
configuration Flash Debug KEAZN64xxx2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: KEAZN64xxx2
  group Include
    Include/: CLK.h derivative.h typedefs.h UART.h
  group Sources
    Sources/: CLK.c main.c UART.c
  group Startup
    Startup/: cstartup_M_KEAZ128.s cstartup_M_KEAZN64.s low_level_init.c
