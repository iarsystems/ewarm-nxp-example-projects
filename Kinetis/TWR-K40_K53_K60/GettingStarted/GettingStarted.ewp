# IAR project GettingStarted.ewp, settings and files
configuration K40 RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 NXP MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: K40
  ICCARM.CCIncludePath2: K40
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/K40X_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration K40 Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH; K40
  ILINK.IlinkIcfFile: config/K40X_Flash.icf
configuration K60 RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  ICCARM.CCDefines: K60
  ICCARM.CCIncludePath2: K60
  ILINK.IlinkIcfFile: config/K60X_ram.icf
configuration K60 Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  ICCARM.CCDefines: FLASH; K60
  ICCARM.CCIncludePath2: K60
  ILINK.IlinkIcfFile: config/K60X_Flash.icf
configuration K53 RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: K53
  ICCARM.CCIncludePath2: K53
  ILINK.IlinkIcfFile: config/K53X_ram.icf
configuration K53 Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DX256Zxxx10 NXP MK53DX256Zxxx10
  ICCARM.CCDefines: FLASH; K53
  ICCARM.CCIncludePath2: K53
  ILINK.IlinkIcfFile: config/K53X_Flash.icf
configuration K70 RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 NXP MK70FN1M0xxx12
  ICCARM.CCDefines: K70
  ICCARM.CCIncludePath2: K70
  ILINK.IlinkIcfFile: config/K70X_ram.icf
configuration K70 Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 NXP MK70FN1M0xxx12
  ICCARM.CCDefines: FLASH; K70
  ICCARM.CCIncludePath2: K70
  ILINK.IlinkIcfFile: config/K70X_Flash.icf
configuration K20 RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK20DX256xxx7 NXP MK20DX256xxx7
  ICCARM.CCDefines: K20
  ICCARM.CCIncludePath2: K20
  ILINK.IlinkIcfFile: config/K20X_ram.icf
configuration K20 Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK20DX256xxx7 NXP MK20DX256xxx7
  ICCARM.CCDefines: FLASH; K20
  ICCARM.CCIncludePath2: K20
  ILINK.IlinkIcfFile: config/K20X_Flash.icf
configuration K20-50MHz RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK20DN128xxx5 NXP MK20DN128xxx5
  ICCARM.CCDefines: K20
  ICCARM.CCIncludePath2: K20
  ILINK.IlinkIcfFile: config/K20X_ram.icf
configuration K20-50MHz Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK20DN128xxx5 NXP MK20DN128xxx5
  ICCARM.CCDefines: FLASH; K20
  ICCARM.CCIncludePath2: K20
  ILINK.IlinkIcfFile: config/K20X_Flash.icf
configuration KE15 RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKE15D256xxx7 NXP MKE15D256xxx7
  ICCARM.CCDefines: KE15
  ICCARM.CCIncludePath2: KE15
  ILINK.IlinkIcfFile: config/KE15_ram.icf
configuration KE15 Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKE15D256xxx7 NXP MKE15D256xxx7
  ICCARM.CCDefines: FLASH; KE15
  ICCARM.CCIncludePath2: KE15
  ILINK.IlinkIcfFile: config/K20X_Flash.icf
configuration K21-50MHz RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK21DN512xxx5 NXP MK21DN512xxx5
  ICCARM.CCDefines: K21
  ICCARM.CCIncludePath2: K21
  ILINK.IlinkIcfFile: config/K21X_ram.icf
configuration K21-50MHz Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK21DN512xxx5 NXP MK21DN512xxx5
  ICCARM.CCDefines: FLASH; K21
  ICCARM.CCIncludePath2: K21
  ILINK.IlinkIcfFile: config/K21X_Flash.icf
configuration KL25 Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  ICCARM.CCDefines: FLASH; KL25
  ICCARM.CCIncludePath2: KL25
  ILINK.IlinkIcfFile: config/KL25_Flash.icf
configuration KL25 RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  ICCARM.CCDefines: KL25
  ICCARM.CCIncludePath2: KL25
  ILINK.IlinkIcfFile: config/KL25_ram.icf
  group (top)
    ./: low_level_init.c main.c readme.txt
  group K20
    K20/: board.h cstartup_M_K20.s
  group K21
    K21/: board.h cstartup_M_K21.s
  group K40
    K40/: board.h cstartup_M_K40.s
  group K53
    K53/: board.h cstartup_M_K53.s
  group K60
    K60/: board.h cstartup_M_K60.s
  group K70
    K70/: board.h cstartup_M_K70.s
  group KE15
    KE15/: board.h cstartup_M_KE15.s
  group KL25
    KL25/: board.h cstartup_M_KL25.s
