<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/slcd_k40_tower.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>slcd_k40_tower</project>
        <configuration>FLASH_256KB_PFLASH</configuration>
      </member>
      <member>
        <project>slcd_k40_tower</project>
        <configuration>FLASH_256KB_PFLASH_256KB_DFLASH</configuration>
      </member>
      <member>
        <project>slcd_k40_tower</project>
        <configuration>RAM_64KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
