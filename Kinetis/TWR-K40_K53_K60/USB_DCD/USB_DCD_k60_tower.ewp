# IAR project USB_DCD_k60_tower.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCDiagSuppress: Pa082,Pe068,Pe520,Pe940
  ICCARM.CCIncludePath2: common; cpu; drivers\uart; drivers\mcg; drivers\pmc; drivers\rtc; drivers\wdog; drivers\adc16; platforms; Dual_Role
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_DCD_k60_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: common/128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_512KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: common/512KB_Pflash.icf
configuration FLASH_256KB_PFLASH_256KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DX256xxx10 NXP MK60DX256xxx10
  ILINK.IlinkIcfFile: common/256KB_Pflash_256KB_Dflash.icf
  group common
    common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers/mcg
    drivers/mcg/: mcg.c
  group drivers/uart
    drivers/uart/: uart.c
  group drivers/wdog
    drivers/wdog/: wdog.c
  group project
    ./: main.c RingBuffer.c USB.c USB_CDC.c USB_DCD.c
  group project/Dual_Role
    Dual_Role/: i2c.c MAX3353.c
