<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/hscmp_k53_tower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/hscmp_k60_tower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/hscmp_k40_tower.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>hscmp_k40_tower</project>
        <configuration>FLASH_256KB_PFLASH</configuration>
      </member>
      <member>
        <project>hscmp_k40_tower</project>
        <configuration>FLASH_256KB_PFLASH_256KB_DFLASH</configuration>
      </member>
      <member>
        <project>hscmp_k40_tower</project>
        <configuration>RAM_64KB</configuration>
      </member>
      <member>
        <project>hscmp_k60_tower</project>
        <configuration>FLASH_512KB_PFLASH</configuration>
      </member>
      <member>
        <project>hscmp_k60_tower</project>
        <configuration>FLASH_256KB_PFLASH_256KB_DFLASH</configuration>
      </member>
      <member>
        <project>hscmp_k60_tower</project>
        <configuration>RAM_128KB</configuration>
      </member>
      <member>
        <project>hscmp_k53_tower</project>
        <configuration>FLASH_512KB_PFLASH</configuration>
      </member>
      <member>
        <project>hscmp_k53_tower</project>
        <configuration>FLASH_256KB_PFLASH_256KB_DFLASH</configuration>
      </member>
      <member>
        <project>hscmp_k53_tower</project>
        <configuration>RAM_128KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
