# IAR project USB_DCD_k70_tower.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 NXP MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K70F120M; DDR_INIT
  ICCARM.CCIncludePath2: ..\..\..\src\projects\USB_DCD; ..\..\..\src\projects\USB_DCD\Dual_Role; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\dsp; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\sai; ..\..\..\src\drivers\sdram; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_DCD_k70_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../config_files/128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_1M (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config_files/1MB_Pflash.icf
  group (top)
    ./: Readme.txt
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group config
    ../config_files/: 128KB_Ram.icf 128MB_DDR2.icf 1MB_Pflash.icf
    ../../../src/platforms/: iar.h
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group drivers/adc16
    ../../../src/drivers/adc16/: adc16.c adc16.h
  group drivers/dsp
    ../../../src/drivers/dsp/: dsp.h dsp_asm.s
  group drivers/enet
    ../../../src/drivers/enet/: enet.c enet.h eth.h eth_phy.c eth_phy.h mii.c mii.h nbuf.c nbuf.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/sai
    ../../../src/drivers/sai/: sai.c sai.h
  group drivers/sdram
    ../../../src/drivers/sdram/: sdram.c sdram.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group platforms
    ../../../src/platforms/: twr-k70f120m.h
  group project
    ../../../src/projects/USB_DCD/: FslTypes.h isr.h main.c RingBuffer.c RingBuffer.h USB.c USB.h USB_CDC.c USB_CDC.h USB_DCD.c USB_DCD.h USB_Desc.h USB_Reg.h
  group project/Dual_Role
    ../../../src/projects/USB_DCD/Dual_Role/: bsp_K70.c bsp_K70.h i2c_1.c i2c_1.h MAX3353.c MAX3353.h psptypes.h Settings.h
