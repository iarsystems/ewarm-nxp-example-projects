<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/lptmr_k70_tower.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lptmr_k70_tower</project>
        <configuration>FLASH_1M</configuration>
      </member>
      <member>
        <project>lptmr_k70_tower</project>
        <configuration>RAM_128KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
