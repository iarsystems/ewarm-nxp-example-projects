# IAR project GettingStarted.ewp, settings and files
configuration K70 RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 NXP MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: K70
  ICCARM.CCIncludePath2: K70
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/K70X_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration K70 Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH; K70
  ILINK.IlinkIcfFile: config/K70X_Flash.icf
  group (top)
    ./: low_level_init.c main.c readme.txt
  group K70
    K70/: board.h cstartup_M_K70.s
