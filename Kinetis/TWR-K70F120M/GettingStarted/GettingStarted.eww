<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GettingStarted.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>GettingStarted</project>
        <configuration>K40 Flash Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K40 RAM Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K60 Flash Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K60 RAM Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K53 Flash Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K53 RAM Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K70 Flash Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K70 RAM Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K20 Flash Debug</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>K20 RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
