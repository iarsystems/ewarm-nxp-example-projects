# IAR project GPIO and ADC.ewp, settings and files
configuration Flash Debug KEA64 (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ64xxx4 NXP KEAZ64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: KEAZ64xxx4
  ICCARM.CCIncludePath2: Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO and ADC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Include
    Include/: CLK.h derivative.h typedefs.h
  group Sources
    Sources/: ADC.c CLK.c KBI.c main.c
  group Startup
    Startup/: cstartup_M_KEAZN64.s low_level_init.c
