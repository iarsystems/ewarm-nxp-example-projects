<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/mmcau_sha1_test.ewp</path>
  </project>
  <batchBuild/>
</workspace>
