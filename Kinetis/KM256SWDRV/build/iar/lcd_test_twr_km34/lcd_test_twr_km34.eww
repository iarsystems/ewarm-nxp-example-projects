<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/lcd_test_twr_km34.ewp</path>
  </project>
  <batchBuild/>
</workspace>
