<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/lowpower_app_tower.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lowpower_app_tower</project>
        <configuration>FLASH_1MB_PFLASH</configuration>
      </member>
      <member>
        <project>lowpower_app_tower</project>
        <configuration>FLASH_512KB_PFLASH</configuration>
      </member>
      <member>
        <project>lowpower_app_tower</project>
        <configuration>RAM_128KB</configuration>
      </member>
      <member>
        <project>lowpower_app_tower</project>
        <configuration>RAM_64KB</configuration>
      </member>
      <member>
        <project>lowpower_app_tower</project>
        <configuration>FLASH_512KB_PFLASH_128KB_DFLASH</configuration>
      </member>
      <member>
        <project>lowpower_app_tower</project>
        <configuration>FLASH_512KB_PFLASH_512KB_DFLASH</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
