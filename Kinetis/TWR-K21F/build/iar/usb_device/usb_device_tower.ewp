# IAR project usb_device_tower.ewp, settings and files
configuration FLASH_1MB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 NXP MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER; TWR_K21F120M
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Core\Include; ..\..\..\src\projects\usb_device; ..\..\..\src\projects\usb_device\bsp; ..\..\..\src\common; ..\..\..\src\platforms; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\cmp; ..\..\..\src\drivers\rnga; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\sai; ..\..\..\src\drivers\smc; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_device_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../config files/1MB_Pflash_USB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_128KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Core\Include; ..\..\..\src\projects\usb_device; ..\..\..\src\projects\usb_device\bsp; ..\..\..\src\common; ..\..\..\src\platforms; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\sai; ..\..\..\src\drivers\smc; ..\
  ILINK.IlinkIcfFile: ../config files/128KB_Ram.icf
configuration FLASH_512KB_PFLASH_512KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkOutputFile: hello_world_tower.out
  ILINK.IlinkIcfFile: ../config files/512KB_Pflash_512KB_Dflash_USB.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK21F12.h MK22F12.h
  group drivers/adc16
    ../../../src/drivers/adc16/: adc16.c adc16.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rnga
    ../../../src/drivers/rnga/: rnga.c rnga.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/sai
    ../../../src/drivers/sai/: sai.c sai.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Ram.icf 1MB_Pflash.icf 512KB_Pflash.icf 512KB_Pflash_128KB_Dflash.icf 512KB_Pflash_512KB_Dflash.icf 512KB_Pflash_512KB_Dflash_USB.icf 64KB_Ram.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/usb_device/: isr.h Readme.txt ring_buffer.c ring_buffer.h Settings.h usb.c usb.h usb_cdc.c usb_cdc.h usb_descriptor.h usb_main.c usb_reg.h
  group project/bsp
    ../../../src/projects/usb_device/bsp/: bsp_K20.c bsp_K20.h
  group semihosting
    ../../../src/semihosting/iar/: read.c write.c
