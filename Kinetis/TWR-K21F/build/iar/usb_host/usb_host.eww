<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/usb_host_tower.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>usb_host_tower</project>
        <configuration>FLASH_1MB_PFLASH</configuration>
      </member>
      <member>
        <project>usb_host_tower</project>
        <configuration>FLASH_512KB_PFLASH_512KB_DFLASH</configuration>
      </member>
      <member>
        <project>usb_host_tower</project>
        <configuration>RAM_128KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
