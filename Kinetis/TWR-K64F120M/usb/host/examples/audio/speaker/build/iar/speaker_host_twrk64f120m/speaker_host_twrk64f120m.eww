<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/speaker_host_twrk64f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../../../../../mqx/build/iar/bsp_twrk64f120m/bsp_twrk64f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../../../../../mqx/build/iar/psp_twrk64f120m/psp_twrk64f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../../../../../mfs/build/iar/mfs_twrk64f120m/mfs_twrk64f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../../../../../shell/build/iar/shell_twrk64f120m/shell_twrk64f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../../../build/iar/usbh_twrk64f120m/usbh_twrk64f120m.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>psp_twrk64f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_twrk64f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk64f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk64f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbh_twrk64f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>speaker_host_twrk64f120m</project>
        <configuration>Int Flash Debug</configuration>
      </member>
      <member>
        <project>psp_twrk64f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>bsp_twrk64f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk64f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk64f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbh_twrk64f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>speaker_host_twrk64f120m</project>
        <configuration>Int Flash Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
