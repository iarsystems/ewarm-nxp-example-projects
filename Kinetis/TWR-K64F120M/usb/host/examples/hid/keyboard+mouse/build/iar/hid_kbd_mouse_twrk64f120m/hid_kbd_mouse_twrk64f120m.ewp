# IAR project hid_kbd_mouse_twrk64f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk64f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk64f120m.iar/debug/bsp/Sources; ../../../../../../../../lib/twrk64f120m.iar/debug; ../../../../../../../../lib/twrk64f120m.iar/debug/bsp; ../../../../../../../../lib/twrk64f120m.iar/debug/psp; ../../../../../../../../lib/twrk64f120m.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: hid_kbd_mouse_twrk64f120m.srec
  ILINK.IlinkOutputFile: hid_kbd_mouse.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk64f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk64f120m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk64f120m.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk64f120m.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk64f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk64f120m.iar/release/bsp/Sources; ../../../../../../../../lib/twrk64f120m.iar/release; ../../../../../../../../lib/twrk64f120m.iar/release/bsp; ../../../../../../../../lib/twrk64f120m.iar/release/psp; ../../../../../../../../lib/twrk64f120m.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk64f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk64f120m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk64f120m.iar/release/psp/psp.a; ../../../../../../../../lib/twrk64f120m.iar/release/usb/usbh.a
  group (top)
    ./: readme.txt
  group Source
    ../../../: hidkeyboard.c hidkeyboard.h hidmouse.c hidmouse.h main.c usb_classes.c usb_classes.h
