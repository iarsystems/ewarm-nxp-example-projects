<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TWR-K64F120M-OOBE.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>TWR-K64F120M-OOBE</project>
        <configuration>FLASH_1MB_PFLASH</configuration>
      </member>
      <member>
        <project>TWR-K64F120M-OOBE</project>
        <configuration>FLASH_512KB_PFLASH</configuration>
      </member>
      <member>
        <project>TWR-K64F120M-OOBE</project>
        <configuration>FLASH_512KB_PFLASH_128KB_DFLASH</configuration>
      </member>
      <member>
        <project>TWR-K64F120M-OOBE</project>
        <configuration>RAM_128KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
