# IAR project TWR-K64F120M-OOBE.ewp, settings and files
configuration FLASH_512KB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; TOWER; TWR_K64F120M
  ICCARM.CCIncludePath2: ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\fpu; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\sai; ..\..\..\src\drivers\smc; ..\..\..\src\platforms; ..\; ..\..\..\src\projects\TWR-K64F120M-OOBE; ..\..\..\src\projects\TWR-K64F120M-OOBE\adc_demo; ..\..\..\src\projects\TWR-K64F120M-OOBE\i2c; ..\..\..\src\projects\TWR-K64F120M-OOBE\irq; ..\..\..\src\projects\TWR-K64F120M-OOBE\led; ..\..\..\src\projects\TWR-K64F120M-OOBE\pdb_adc; ..\..\..\src\projects\TWR-K64F120M-OOBE\rtc; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_device; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_device\bsp; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_host; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_host\bsp; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_host\classes\common; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_host\classes\hid; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_host\classes\hub; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_host\driver; ..\..\..\src\projects\TWR-K64F120M-OOBE\usb_host\host_common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TWR-K64F120M-OOBE.bin
  ILINK.IlinkOutputFile: hello_world_tower.out
  ILINK.IlinkIcfFile: ../config files/512KB_Pflash_USB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_1MB_PFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config files/1MB_Pflash_USB.icf
configuration RAM_128KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config files/256KB_Ram_USB.icf
configuration FLASH_512KB_PFLASH_128KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config files/512KB_Pflash_128KB_Dflash_USB.icf
  group common
    ../../../src/common/: assert.c assert.h common.h io.c io.h memtest.c memtest.h startup.c startup.h
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK64F12.h
  group drivers/adc16
    ../../../src/drivers/adc16/: adc16.c adc16.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/fpu
    ../../../src/drivers/fpu/: fpu.h fpu_asm.s
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/mmcau
    ../../../src/drivers/mmcau/: cau_api.h mmcau_lib.a
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rnga
    ../../../src/drivers/rnga/: rnga.c rnga.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/sai
    ../../../src/drivers/sai/: sai.c sai.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 1MB_Pflash.icf 256KB_Ram.icf 512KB_Pflash.icf 512KB_Pflash_128KB_Dflash.icf
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/TWR-K64F120M-OOBE/: isr.h TWR-K64F120M-OOBE.c
  group project/adc_demo
    ../../../src/projects/TWR-K64F120M-OOBE/adc_demo/: hw_trig_test.c hw_trig_test.h
  group project/ethernet
    ../../../src/projects/TWR-K64F120M-OOBE/enet/: ethernet.c ethernet.h mii.c mii.h
  group project/i2c
    ../../../src/projects/TWR-K64F120M-OOBE/i2c/: hal_dev_mma8451.c hal_dev_mma8451.h hal_i2c.c hal_i2c.h i2c.c i2c.h i2c_demo.c
  group project/irq
    ../../../src/projects/TWR-K64F120M-OOBE/irq/: irq_demo.c
  group project/led
    ../../../src/projects/TWR-K64F120M-OOBE/led/: led.c led.h
  group project/sdhc
    ../../../src/projects/TWR-K64F120M-OOBE/sdhc/: esdhc.h esdhc_test.c
  group project/usb_device
    ../../../src/projects/TWR-K64F120M-OOBE/usb_device/: ring_buffer.c ring_buffer.h Settings.h usb.c usb.h usb_cdc.c usb_cdc.h usb_descriptor.h usb_main.c usb_reg.h
  group project/usb_device/bsp
    ../../../src/projects/TWR-K64F120M-OOBE/usb_device/bsp/: bsp_K20.c bsp_K20.h
  group project/usb_host
    ../../../src/projects/TWR-K64F120M-OOBE/usb_host/: hidmouse.c hidmouse.h
  group project/usb_host/bsp
    ../../../src/projects/TWR-K64F120M-OOBE/usb_host/bsp/: MK20.c
  group project/usb_host/classes/common
    ../../../src/projects/TWR-K64F120M-OOBE/usb_host/classes/common/: usb_classes.c usb_classes.h
  group project/usb_host/classes/hid
    ../../../src/projects/TWR-K64F120M-OOBE/usb_host/classes/hid/: usb_host_hid.c usb_host_hid.h
  group project/usb_host/classes/hub
    ../../../src/projects/TWR-K64F120M-OOBE/usb_host/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group project/usb_host/driver
    ../../../src/projects/TWR-K64F120M-OOBE/usb_host/driver/: khci.c khci.h psptypes.h types.h usb_bsp.h usb_desc.h usb_host.h usbevent.c usbevent.h usbmsgq.c usbmsgq.h usbprv.h usbprv_host.h usbsem.c usbsem.h
  group project/usb_host/host_common
    ../../../src/projects/TWR-K64F120M-OOBE/usb_host/host_common/: host_ch9.c host_ch9.h host_close.c host_close.h host_cnfg.h host_cnl.c host_cnl.h host_common.c host_common.h host_debug.h host_dev_list.c host_dev_list.h host_driver.c host_driver.h host_main.c host_main.h host_rcv.c host_rcv.h host_shut.c host_shut.h host_snd.c host_snd.h hostapi.h
  group semihosting
    ../../../src/semihosting/iar/: read.c write.c
