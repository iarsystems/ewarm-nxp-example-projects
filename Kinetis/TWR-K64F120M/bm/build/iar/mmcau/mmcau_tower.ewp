# IAR project mmcau_tower.ewp, settings and files
configuration FLASH_512KB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; TOWER; TWR_K64F120M; NXP_MMCAU
  ICCARM.CCIncludePath2: ..\..\..\src\projects\mmcau; ..\..\..\src\projects\mmcau\source; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mmcau; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\sai; ..\..\..\src\drivers\smc; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mmcau_tower.bin
  ILINK.IlinkOutputFile: hello_world_tower.out
  ILINK.IlinkIcfFile: ../config files/512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_1MB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\src\projects\mmcau; ..\..\..\src\projects\mmcau\mmcau_lib; ..\..\..\src\projects\mmcau\mmcau_tests; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\sai; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\mmcau; ..\..\..\src\drivers\rnga; ..\..\..\src\platforms; ..\
  ILINK.IlinkIcfFile: ../config files/1MB_Pflash.icf
configuration RAM_256KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ../config files/256KB_Ram.icf
configuration FLASH_512KB_PFLASH_128KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ../config files/512KB_Pflash_128KB_Dflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK64F12.h
  group drivers/adc16
    ../../../src/drivers/adc16/: adc16.c adc16.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/mmcau
    ../../../src/drivers/mmcau/: cau_api.h mmcau_lib.a
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rnga
    ../../../src/drivers/rnga/: rnga.c rnga.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/sai
    ../../../src/drivers/sai/: sai.c sai.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 1MB_Pflash.icf 256KB_Ram.icf 512KB_Pflash.icf 512KB_Pflash_128KB_Dflash.icf
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/mmcau/: isr.h mmcau.c
  group project/test
    ../../../src/projects/mmcau/mmcau_tests/: aes.c aes.h crypto_common.c crypto_common.h des.c des.h des3.c des3.h md5.c md5.h sha1.c sha1.h sha256.c sha256.h
  group semihosting
    ../../../src/semihosting/iar/: read.c write.c
