<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/lptmr_tower.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lptmr_tower</project>
        <configuration>FLASH_1MB_PFLASH</configuration>
      </member>
      <member>
        <project>lptmr_tower</project>
        <configuration>FLASH_512KB_PFLASH</configuration>
      </member>
      <member>
        <project>lptmr_tower</project>
        <configuration>FLASH_512KB_PFLASH_128KB_DFLASH</configuration>
      </member>
      <member>
        <project>lptmr_tower</project>
        <configuration>RAM_256KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
