# IAR project usb_host_tower.ewp, settings and files
configuration FLASH_1MB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; TOWER; TWR_K64F120M
  ICCARM.CCIncludePath2: ..\; ..\..\..\src\projects\usb_host; ..\..\..\src\projects\usb_host\bsp; ..\..\..\src\projects\usb_host\classes\common; ..\..\..\src\projects\usb_host\classes\hid; ..\..\..\src\projects\usb_host\classes\hub; ..\..\..\src\projects\usb_host\common; ..\..\..\src\projects\usb_host\driver; ..\..\..\src\projects\usb_host\host_common; ..\..\..\src\cpu; ..\..\..\src\platforms; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\sai; ..\..\..\src\drivers\smc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_host_tower.bin
  ILINK.IlinkOutputFile: hello_world_tower.out
  ILINK.IlinkIcfFile: ../config files/1MB_Pflash_USB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_256KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config files/256KB_Ram_USB.icf
configuration FLASH_512KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config files/512KB_Pflash_USB.icf
configuration FLASH_512KB_PFLASH_128KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config files/512KB_Pflash_128KB_Dflash_USB.icf
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK64F12.h
  group drivers/adc16
    ../../../src/drivers/adc16/: adc16.c adc16.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/mmcau
    ../../../src/drivers/mmcau/: cau_api.h mmcau_lib.a
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rnga
    ../../../src/drivers/rnga/: rnga.c rnga.h
  group drivers/sai
    ../../../src/drivers/sai/: sai.c sai.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 1MB_Pflash.icf 1MB_Pflash_USB.icf 256KB_Ram.icf 512KB_Pflash.icf 512KB_Pflash_128KB_Dflash.icf
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/usb_host/: hidmouse.c hidmouse.h isr.h
  group project/bsp
    ../../../src/projects/usb_host/bsp/: bsp_K20.c bsp_K20.h MK20.c Settings.h
  group project/classes/common
    ../../../src/projects/usb_host/classes/common/: usb_classes.c usb_classes.h
  group project/classes/hid
    ../../../src/projects/usb_host/classes/hid/: usb_host_hid.c usb_host_hid.h
  group project/classes/hub
    ../../../src/projects/usb_host/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group project/common
    ../../../src/common/: common.h
    ../../../src/projects/usb_host/common/: rtc.c rtc.h startup.c startup.h
  group project/driver
    ../../../src/projects/usb_host/driver/: khci.c khci.h psptypes.h types.h usb.h usb_bsp.h usb_desc.h usbevent.c usbevent.h usbmsgq.c usbmsgq.h usbprv.h usbprv_host.h usbsem.c usbsem.h
  group project/host_common
    ../../../src/projects/usb_host/host_common/: host_ch9.c host_ch9.h host_close.c host_close.h host_cnfg.h host_cnl.c host_cnl.h host_common.c host_common.h host_debug.h host_dev_list.c host_dev_list.h host_driver.c host_driver.h host_main.c host_main.h host_rcv.c host_rcv.h host_shut.c host_shut.h host_snd.c host_snd.h hostapi.h
  group semihosting
    ../../../src/semihosting/iar/: read.c write.c
