# IAR project psp_twrk64f120m_lp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; MQX_ENABLE_LOW_POWER=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../../config/twrk64f120m; ../../../../config/common; ../../../source/include; ../../../source/tad; ../../../source/io/adc/kadc; ../../../source/io/adc; ../../../source/io/cm; ../../../source/io/dma; ../../../source/io/enet/macnet; ../../../source/io/enet/phy; ../../../source/io/enet; ../../../source/io/esdhc; ../../../source/io/flashx/NXP; ../../../source/io/flashx; ../../../source/io/can/flexcan; ../../../source/io/gpio/kgpio; ../../../source/io/gpio; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/twrk64f120m; ../../../source/io/debug; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/pccard; ../../../source/io/pcflash; ../../../source/io/rtc; ../../../source/io/sai; ../../../source/io/sai/int; ../../../source/io/sdcard/sdcard_esdhc; ../../../source/io/sdcard/sdcard_spi; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tchres; ../../../source/io/tfs; ../../../source/io/timer; ../../../source/io/usb; ../../../source/io/usb_dcd; ../../../source/io/usb_dcd/polled; ../../../source/io/usb_dcd/int
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: "../../../../mqx/build/bat/psp_twrk64f120m.bat" "../../../.." "../../../../lib/twrk64f120m.iar/debug/psp" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MQX_ENABLE_LOW_POWER=1; MQX_DISABLE_CONFIG_CHECK=1
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../mqx/build/bat/psp_twrk64f120m.bat" "../../../.." "../../../../lib/twrk64f120m.iar/release/psp" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group PSP Cortex
    ../../../source/psp/cortex_m/core/M4/: boot.S dispatch.S support.S
    ../../../source/psp/cortex_m/: cortex.c cortex.h int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c kinetis.h kinetis_mpu.c kinetis_mpu.h mem_copy.c mem_zero.c nvic.c nvic.h psp.h psp_abi.h psp_comp.h psp_cpu.h psp_cpudef.h psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_math.h psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_prv.h psp_psti.c psp_rev.h psp_seti.c psp_supp.c psp_supp.h psp_tiad.c psp_tida.c psp_tihr.c psp_time.h psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c psptypes.h sc_irdyq.c stack_bu.c stack_de.c stack_st.c
    ../../../source/psp/cortex_m/cpu/: kinetis_fcan.h MK64F12.h
  group PSP Cortex/compiler
    ../../../source/psp/cortex_m/compiler/iar/: asm_mac.h comp.c comp.h kernel_symbols.S
  group PSP Generic/fio
    ../../../source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group PSP Generic/include
    ../../../source/include/: charq.h eds.h eds_prv.h edserial.h edserprv.h event.h event_prv.h fio.h fio_prv.h fpio_prv.h gen_rev.h io.h io_prv.h io_rev.h ioctl.h ipc.h ipc_pcb.h ipc_pcbv.h ipc_prv.h ipcrtprv.h klog.h log.h log_prv.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwsem.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_macros.h mqx_prv.h mqx_str.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h posix.h queue.h sem.h sem_prv.h timer.h timer_prv.h unicode.h watchdog.h watchdog_prv.h
  group PSP Generic/io
    ../../../source/io/: io_ghand.c io_init.c io_inst.c io_instx.c io_shand.c io_uinst.c
  group PSP Generic/kernel
    ../../../source/kernel/: event.c idletask.c inittask.c int.c ipc.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mem.c mqx.c msg.c msgpool.c msgq.c mutex.c name.c partition.c queue.c sched.c sem.c task.c taskq.c time.c timer.c watchdog.c
  group PSP Generic/string
    ../../../source/string/: str_utos.c strnlen.c unicode.c
  group PSP Generic/tad
    ../../../source/tad/: tad.c tad.h
  group User Config
    ../../../../config/common/: small_ram_config.h
    ../../../../config/twrk64f120m/: user_config.h
