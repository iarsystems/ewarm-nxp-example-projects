# IAR project mfs_ramdisk_twrk64f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; BSPCFG_ENABLE_SAI=0; BSPCFG_ENABLE_SPI0=0
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../../../../lib/twrk64f120m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk64f120m.iar/debug/bsp/Sources; ../../../../../../lib/twrk64f120m.iar/debug; ../../../../../../lib/twrk64f120m.iar/debug/bsp; ../../../../../../lib/twrk64f120m.iar/debug/psp; ../../../../../../lib/twrk64f120m.iar/debug/mfs; ../../../../../../lib/twrk64f120m.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mfs_ramdisk_twrk64f120m.srec
  ILINK.IlinkOutputFile: mfs_ramdisk.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk64f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk64f120m.iar/debug/bsp/bsp_fb.a; ../../../../../../lib/twrk64f120m.iar/debug/psp/psp.a; ../../../../../../lib/twrk64f120m.iar/debug/mfs/mfs.a; ../../../../../../lib/twrk64f120m.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: BSPCFG_ENABLE_SAI=0; BSPCFG_ENABLE_SPI0=0
  ICCARM.CCIncludePath2: ../../../../../../lib/twrk64f120m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk64f120m.iar/release/bsp/Sources; ../../../../../../lib/twrk64f120m.iar/release; ../../../../../../lib/twrk64f120m.iar/release/bsp; ../../../../../../lib/twrk64f120m.iar/release/psp; ../../../../../../lib/twrk64f120m.iar/release/mfs; ../../../../../../lib/twrk64f120m.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk64f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk64f120m.iar/release/bsp/bsp_fb.a; ../../../../../../lib/twrk64f120m.iar/release/psp/psp.a; ../../../../../../lib/twrk64f120m.iar/release/mfs/mfs.a; ../../../../../../lib/twrk64f120m.iar/release/shell/shell.a
  group (top)
    ./: readme.txt
  group Source
    ../../../: Shell_Task.c Tasks.c
