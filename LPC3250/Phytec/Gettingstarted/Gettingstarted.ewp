# IAR project Gettingstarted.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC3250 NXP LPC3250
  ICCARM.CCIncludePath2: ; board\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: Gettingstarted.out
  ILINK.IlinkIcfFile: config/LPC3000_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug xRAM (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: ICODE_IRAM_DEF
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
configuration Release iRAM boot from NAND512(64M) (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Release iRAM boot from NAND256(32M) (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Release xRAM boot from NAND512(64M) (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
configuration Release xRAM boot from NAND256(32M) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NAND256
  ICCARM.CCOptLevel: 3
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
configuration Release iRAM boot level 2 from NAND256(32M) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NAND256
  ICCARM.CCOptLevel: 3
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_iRAM_Boot_level_2.icf
configuration Release iRAM boot level 2 from NAND512(64M) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NAND256
  ICCARM.CCOptLevel: 3
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_iRAM_Boot_level_2.icf
  group (top)
    ./: main.c readme.txt write.c
  group MMU
    board/: arm926ej_cp15_drv.c ttbl.c
  group Startup
    board/: cstartup.s
  group Startup/BOOT
    board/: nand_bootloader.c
  group Startup/iRAM
    board/: iram_init.c
