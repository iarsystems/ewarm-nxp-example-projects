# IAR project USBMouse.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC3250 NXP LPC3250
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC3000_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug xRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  AARM.ADefines: ICODE_IRAM_DEF
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
configuration Release xRAM boot from NAND (ARM)
  as the first configuration, except:
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
  group (top)
    app/: buttons.c main.c
    ./: readme.txt
  group MMU
    board/: arm926ej_cp15_drv.c ttbl.c
  group modules
    modules/: drv_intc.c lpc32xx_clkpwr_driver.c lpc32xx_i2c_driver.c lpc32xx_pca9532_driver.c
  group Startup
    board/: cstartup.s
  group Startup/BOOT
    board/: nand_bootloader.c
  group USB/Class
    app/: hid_mouse.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
