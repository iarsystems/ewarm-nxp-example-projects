# IAR project Gettingstarted.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC3250 NXP LPC3250
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: Gettingstarted.out
  ILINK.IlinkIcfFile: config/LPC3000_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug xRAM (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: ICODE_IRAM_DEF
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
configuration Release xRAM boot from NAND (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
  group (top)
    ./: main.c readme.txt
  group MMU
    board/: arm926ej_cp15_drv.c ttbl.c
  group modules
    modules/: drv_intc.c
  group Startup
    board/: cstartup.s
  group Startup/BOOT
    board/: nand_bootloader.c
