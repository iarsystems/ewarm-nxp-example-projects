# IAR project MassStorage.ewp, settings and files
configuration Debug xRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC3250 NXP LPC3250
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ICODE_IRAM_DEF
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC3000_xRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release xRAM boot from NAND (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  AARM.ADefines: BOOT_LEVEL_2
  group (top)
    app/: main.c
    ./: readme.txt
  group LUNs
    app/: lun.c
  group LUNs/RAM Disc
    app/: ram_dsk.c ram_dsk_desc.c
  group MMU
    board/: arm926ej_cp15_drv.c ttbl.c
  group modules
    modules/: drv_intc.c
  group Startup
    board/: cstartup.s
  group Startup/BOOT
    board/: nand_bootloader.c
  group USB/Class
    app/: scsi.c scsi_ll.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
