<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GettingStarted.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>GettingStarted</project>
        <configuration>Debug iRAM</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Debug xRAM</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Release iRAM boot from NAND256(32M)</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Release iRAM boot from NAND512(64M)</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Release iRAM boot level 2 from NAND256(32M)</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Release iRAM boot level 2 from NAND512(64M)</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Release xRAM boot from NAND256(32M)</configuration>
      </member>
      <member>
        <project>GettingStarted</project>
        <configuration>Release xRAM boot from NAND512(64M)</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
