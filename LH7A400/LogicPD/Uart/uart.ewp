# IAR project uart.ewp, settings and files
configuration DebugRunFromFlash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LH7A400LPDSDK NXP LH7A400LPDSDK
  ICCARM.CCIncludePath2: ; board\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkIcfFile: config/StandAloneFlashLH7A400LPD.icf
  group (top)
    ./: main.c
  group Common
    board/: arm922t_cp15_drv.c cstartup.s lh7A400_low_init.c ttbl.c
