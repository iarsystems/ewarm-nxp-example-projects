# IAR project FlashMAC71x1_Example.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MAC7111 NXP MAC7111
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: FlashMAC71x1_Example.out
  ILINK.IlinkIcfFile: config/MAC7100_EVB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: FlashMAC71x1_Example.hex
  group (top)
    ./: FlashMAC71x1_Example.c MAC7100FlashConfiguartion.c MAC7100InterruptHandler.c
