# IAR project LedBlink.ewp, settings and files
configuration xFlashDebug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MC9328MX1 NXP MC9328MX1
  ICCARM.CCIncludePath2: app\; board\; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: LedBlink.out
  ILINK.IlinkIcfFile: config/xFlash.icf
  group (top)
    app/: main.c
  group common
    board/: MX1_cstartup.s mx1_init.c
