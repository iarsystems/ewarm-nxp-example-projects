# IAR project AudioDevice.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2478_STK
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: AudioDevice.out
  ILINK.IlinkIcfFile: config/LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2478_STK; SDRAM_DEBUG
  ILINK.IlinkIcfFile: config/LPC2478_SDRAM.icf
  group (top)
    app/: main.c
    ./: readme.txt
  group Modules
    board/: sys.c
  group Modules/Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Modules/GLCD
    modules/: drv_glcd.c
  group Modules/Pictures
    app/: iar_logo.c loudness.c wide_stereo.c
  group Modules/SDRAM
    modules/: sdram_64M_32bit_drv.c
  group Modules/Touch screen
    modules/: drv_touch_scr.c
  group Modules/VS1002
    modules/: drv_vs1002.c
  group USB/Class
    app/: audio_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
