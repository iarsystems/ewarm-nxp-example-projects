<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/emac.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>emac</project>
        <configuration>Flash_Debug_2468</configuration>
      </member>
      <member>
        <project>emac</project>
        <configuration>RAM_Debug_2468</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
