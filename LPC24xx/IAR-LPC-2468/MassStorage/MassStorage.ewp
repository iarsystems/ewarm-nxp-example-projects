# IAR project MassStorage.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2468 NXP LPC2468
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2468; __RAM_DEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MassStorage.out
  ILINK.IlinkIcfFile: config/LPC2468_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2468
  ILINK.IlinkIcfFile: config/LPC2468_Flash.icf
  group (top)
    app/: main.c
    ./: readme.txt
  group Board
    board/: sys.c
  group Luns
    app/: lun.c
  group Luns/SD/MMC
    app/: sd_card_mode.c sd_dsk_desc.c
  group Modules
    modules/: drv_hd44780.c drv_hd44780_cnfg.h drv_hd44780_l.c
  group USB/Class
    app/: scsi.c scsi_ll.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
