# IAR project uip_webserver.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2468 NXP LPC2468
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2468; __RAM_DEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: app\; board\; modules\; uip; uip\httpd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uip_webserver.out
  ILINK.IlinkIcfFile: config/LPC2468_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2468
  ILINK.IlinkIcfFile: config/lpc2468_flash.icf
  group (top)
    app/: clock-arch.c main.c uip-conf.h uipopt.h
    ./: readme.txt
  group Board
    board/: sys.c
  group Modules
    modules/: drv_hd44780.c drv_hd44780_cnfg.h drv_hd44780_l.c LPC24xx_enet.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
