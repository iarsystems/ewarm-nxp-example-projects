<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/rtc.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>rtc</project>
        <configuration>Flash_Debug_2468</configuration>
      </member>
      <member>
        <project>rtc</project>
        <configuration>RAM_Debug_2468</configuration>
      </member>
      <member>
        <project>rtc</project>
        <configuration>Flash_Debug_P2468-SK</configuration>
      </member>
      <member>
        <project>rtc</project>
        <configuration>RAM_Debug_P2468-SK</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
