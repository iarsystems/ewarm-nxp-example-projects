# IAR project emac.ewp, settings and files
configuration RAM_Debug_2468 (ARM, debug)
  General.OGChipSelectEditMenu: LPC2468 NXP LPC2468
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2468
  ICCARM.CCDiagSuppress: Pa082, Pe111, Pe549
  ICCARM.CCIncludePath2: ..\common\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkOutputFile: emac.out
  ILINK.IlinkIcfFile: ../common/icf/LPC2468_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_Debug_2468 (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../common/icf/LPC2468_Flash.icf
  group (top)
    ./: crc32.c emac.c emactest.c
    ../Common/src/: cstartup.s irq.c target.c
