# IAR project tmr.ewp, settings and files
configuration RAM_Debug_2468 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2468 NXP LPC2468
  ICCARM.CCDefines: IAR_LPC_2468
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ..\common\inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: tmr.out
  ILINK.IlinkIcfFile: ../common/icf/LPC2468_RAM.icf
configuration Flash_Debug_2468 (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../common/icf/LPC2468_Flash.icf
  group (top)
    ../Common/src/: cstartup.s irq.c target.c timer.c
    ./: tmrtest.c
