<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SDRAM_NAND_Check.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>SDRAM_NAND_Check</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>SDRAM_NAND_Check</project>
        <configuration>RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
