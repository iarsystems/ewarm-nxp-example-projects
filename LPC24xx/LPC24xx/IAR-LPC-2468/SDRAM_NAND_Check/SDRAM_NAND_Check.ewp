# IAR project SDRAM_NAND_Check.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2468 NXP LPC2468
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2468; __RAM_DEBUG
  ICCARM.CCIncludePath2: ; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDRAM_NAND_Check.srec
  ILINK.IlinkOutputFile: SDRAM_NAND_Check.out
  ILINK.IlinkIcfFile: config/LPC2468_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2468 Philips LPC2468
  ICCARM.CCDefines: IAR_LPC_2468
  ILINK.IlinkIcfFile: config/LPC2468_Flash.icf
  group (top)
    ./: main.c readme.txt sys.c
  group Modules
    modules/: EMC_drv.c
