<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AudioDevice.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>AudioDevice</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>AudioDevice</project>
        <configuration>RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
