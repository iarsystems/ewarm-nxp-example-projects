# IAR project USB_HostDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2478_STK; PRINT_ENABLE
  ICCARM.CCIncludePath2: app; board; modules; host\Host; host\Include; host\fat; host\MassStorage
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: host_demo.out
  ILINK.IlinkIcfFile: config/LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2478_STK; PRINT_ENABLE; SDRAM_DEBUG
  ILINK.IlinkIcfFile: config/LPC2478_SDRAM.icf
  group (top)
    ./: readme.txt
  group app
    app/: main.c
  group app/Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group app/Pictures
    app/: iar_logo.c
  group board
    board/: sys.c
  group board/config
    config/: LPC2478_Flash.icf
  group Host/Classes/MassStorage
    Host/MassStorage/: usbhost_ms.c
  group Host/Classes/MassStorage/Fat
    Host/Fat/: io_cache.c usbhost_fat.c
  group Host/Core
    Host/Host/: usbhost_lpc2468.c
  group Modules
    modules/: drv_glcd.c sdram_64M_32bit_drv.c
