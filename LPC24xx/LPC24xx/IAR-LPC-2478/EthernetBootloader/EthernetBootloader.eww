<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Bootloader/Bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USBMouse/USBMouse.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Bootloader</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>USBMouse</project>
        <configuration>Flash Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
