# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2468 NXP LPC2468
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: EA_LPC_24XX; __RAM_DEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/LPC2468_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2468 Philips LPC2468
  ICCARM.CCDefines: EA_LPC_24XX
  ILINK.IlinkIcfFile: config/LPC2468_Flash.icf
configuration NOR Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2468 Philips LPC2468
  ICCARM.CCDefines: EA_LPC_24XX; __NOR_DEBUG
  AARM.ADefines: __NOR_DEBUG
  ILINK.IlinkIcfFile: config/EmbArtLPC24xx_NOR_Flash.icf
  group (top)
    ./: cstartup.s main.c nor_ll.c readme.txt sys.c
