# IAR project uip_webserver.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: MICRO_BLOX_LPC2478
  ICCARM.CCIncludePath2: app; board; modules; uip; uip\httpd
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uip_webserver.out
  ILINK.IlinkIcfFile: config/LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: clock-arch.c main.c
  group app/Config
    app/: uip-conf.h uipopt.h
  group board
    board/: sys.c
  group config
    config/: LPC2478_Flash.icf
  group Modules
    modules/: LPC24xx_enet.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
