# IAR project VirtualCom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: MICRO_BLOX_LPC2478
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: virtual_com.out
  ILINK.IlinkIcfFile: config/LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c
    ./: readme.txt
  group Modules
    board/: sys.c
  group Modules/UARTs
    app/: uart.c
  group USB/Class
    app/: cd_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
