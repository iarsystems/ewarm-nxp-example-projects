<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/pmu.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>pmu</project>
        <configuration>Flash debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
