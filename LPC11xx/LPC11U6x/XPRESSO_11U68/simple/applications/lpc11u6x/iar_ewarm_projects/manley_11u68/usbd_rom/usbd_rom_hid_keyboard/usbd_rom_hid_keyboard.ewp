# IAR project usbd_rom_hid_keyboard.ewp, settings and files
configuration iflash_manley_11u68 (ARM)
  General.OGChipSelectEditMenu: LPC11U68JBD64 NXP LPC11U68JBD64
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11u6x; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11u6x\config_11U6X; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11u6x\manley_11u68; ..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11u6x\manley_11u68; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11u6x\config_11u6x
  OBJCOPY.OOCOutputFile: usbd_rom_hid_keyboard.bin
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../examples/usbd_rom/usbd_rom_hid_keyboard/: hid_desc.c hid_keyboard.c hid_main.c ms_timer.c
    ../../../../startup_code/: iar_startup_lpc11u6x.s sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_11u6x/manley_11u68/iar_output/Exe/: board_manley_11u68.a
    ../../../../../../software/lpc_core/lpc_chip/chip_11u6x/iar_output/chip_11u6x_lib/Exe/: chip_11u6x_lib.a
