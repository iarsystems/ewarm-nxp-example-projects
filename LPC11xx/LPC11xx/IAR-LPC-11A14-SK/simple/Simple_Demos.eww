<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC/ADC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Blinky/Blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DAC/DAC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DAC_Sine/DAC_Sine.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/EEPROM/EEPROM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/gint/GINT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/gpio/GPIO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/i2c/I2C.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWM/PWM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RS485/RS485.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SSP/SSP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/systick/systick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/timer32/timer32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART/UART.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/wdt/WDT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ADC</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>Blinky</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>DAC</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>DAC_Sine</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>EEPROM</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>GINT</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>GPIO</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>I2C</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>PWM</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>RS485</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>SSP</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>systick</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>timer32</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>UART</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>WDT</project>
        <configuration>Flash Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
