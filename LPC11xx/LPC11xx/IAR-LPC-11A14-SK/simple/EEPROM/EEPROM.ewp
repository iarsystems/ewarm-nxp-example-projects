# IAR project EEPROM.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11A14 NXP LPC11A14
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __DEBUG_FLASH
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\Core\Include; ..\Common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC.srec
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: eeprom.c EEPROMtest.c Readme.txt
  group Common
    ../Common/src/: clkconfig.c cstartup_M.s gpio.c nmi.c system_LPC11Axx.c timer16.c uart.c
