# IAR project Bootloader.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1114 NXP LPC1114
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\Core\Include; src\; ..\..\..\CMSIS\Device\NXP\LPC11xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../LinkerFiles/bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: crc.c IAP.c main.c uart.c xmodem1k.c
    ../: readme.txt
  group CMSIS
    ../../../CMSIS/Device/NXP/LPC11xx/Source/IAR/: startup_LPC11xx.s
    ../../../CMSIS/Device/NXP/LPC11xx/Source/: system_LPC11xx.c
  group linker
    ../LinkerFiles/: bootloader.icf
