<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/../../../../../software/lpc_core/lpc_chip/chip_11u6x/lib_lpc_chip_11u6x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../../software/lpc_core/lpc_board/boards_11u6x/manley_11u68/lib_lpc_board_manley_11u68.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usbd_rom_cdc/usbd_rom_cdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usbd_rom_cdc_uart/usbd_rom_cdc_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usbd_rom_cdc_uartn/usbd_rom_cdc_uartn.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usbd_rom_composite/usbd_rom_composite.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usbd_rom_hid_generic/usbd_rom_hid_generic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usbd_rom_hid_keyboard/usbd_rom_hid_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/usbd_rom_hid_mouse/usbd_rom_hid_mouse.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All_libs_and_Examples</name>
      <member>
        <project>lib_lpc_chip_11u6x</project>
        <configuration>chip_11u6x_lib</configuration>
      </member>
      <member>
        <project>lib_lpc_board_manley_11u68</project>
        <configuration>manley_11u68</configuration>
      </member>
      <member>
        <project>usbd_rom_cdc</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>usbd_rom_cdc_uart</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>usbd_rom_cdc_uartn</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>usbd_rom_composite</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>usbd_rom_hid_generic</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>usbd_rom_hid_keyboard</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>usbd_rom_hid_mouse</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
