<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/../../../../../software/lpc_core/lpc_chip/chip_11u6x/lib_lpc_chip_11u6x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../../software/lpc_core/lpc_board/boards_11u6x/manley_11u68/lib_lpc_board_manley_11u68.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_adc/periph_adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_blinky/periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_bod/periph_bod.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_clkout/periph_clkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_crc/periph_crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_i2c/periph_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_pinint/periph_pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_rtc/periph_rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_ssp/periph_ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_uart_0/periph_uart_0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_uart_n/periph_uart_n.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/periph_wwdt/periph_wwdt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lib_lpc_board_manley_11u68</project>
        <configuration>manley_11u68</configuration>
      </member>
      <member>
        <project>lib_lpc_chip_11u6x</project>
        <configuration>chip_11u6x_lib</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_bod</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_clkout</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_crc</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_pinint</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_uart_0</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_uart_n</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
      <member>
        <project>periph_wwdt</project>
        <configuration>iflash_manley_11u68</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
