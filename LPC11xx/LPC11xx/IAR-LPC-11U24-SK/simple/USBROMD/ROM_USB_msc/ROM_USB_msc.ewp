# IAR project ROM_USB_msc.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U24FBD64_401 NXP LPC11U24FBD64_401
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __DEBUG_FLASH
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Core\Include; inc; ..\..\Common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC.srec
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: DiskImg.c lpc11uxx_usbd_msc_mem.c main.c mem_lpc11uxx_usbdesc.c
    ./: readme.txt
  group Common
    ../../Common/src/: clkconfig.c cstartup_M.s system_LPC11Uxx.c uart.c
  group USBROMD
    inc/: error.h mw_usbd.h mw_usbd_adcuser.h mw_usbd_audio.h mw_usbd_cdc.h mw_usbd_cdcuser.h mw_usbd_core.h mw_usbd_desc.h mw_usbd_dfu.h mw_usbd_dfuuser.h mw_usbd_hid.h mw_usbd_hiduser.h mw_usbd_hw.h mw_usbd_msc.h mw_usbd_mscuser.h mw_usbd_rom_api.h
