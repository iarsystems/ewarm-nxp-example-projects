<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ROM_USB_hid.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ROM_USB_hid</project>
        <configuration>Flash Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
