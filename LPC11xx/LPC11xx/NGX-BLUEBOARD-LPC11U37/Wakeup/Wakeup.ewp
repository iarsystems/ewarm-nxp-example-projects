# IAR project Wakeup.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U37FBD64_501 NXP LPC11U37FBD64_501
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; ..\G_LCD\inc; ..\Common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Common
    ../Common/src/: gpio.c timer32.c
  group Documentation
    ./: Readme.txt
  group Source
    ../G_LCD/src/: glcd_8x8.c glcd_platform_lpc11Uxx.c
    ./: pmu.c pmutest.c
  group Startup
    ../Common/src/: startup_LPC11Uxx.s system_LPC11Uxx.c
