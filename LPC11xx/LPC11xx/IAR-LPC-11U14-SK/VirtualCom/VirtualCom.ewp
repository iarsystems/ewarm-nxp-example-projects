# IAR project VirtualCom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U14FBD48_201 NXP LPC11U14FBD48_201
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_11U14_SK
  ICCARM.CCIncludePath2: ; app; board; modules
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBMouse.srec
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s main.c readme.txt
  group modules
    modules/: drv_hd44780.c drv_hd44780_l.c usb_buffer.c
    app/: uart.c
  group USB/Class
    app/: cd_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_t9.c
  group USB/HW
    modules/: usb_hw.c
