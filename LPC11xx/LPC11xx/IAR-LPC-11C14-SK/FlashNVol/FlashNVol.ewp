# IAR project FlashNVol.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11C14 NXP LPC11C14
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: LPC11XX
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; modules\; ..\..\CMSIS\Device\NXP\LPC11xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashNVol.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: flash_nvol.c main_lpc11xx.c readme.txt
  group CMSIS
    ../../CMSIS/Device/NXP/LPC11xx/Source/IAR/: startup_LPC11xx.s
    ../../CMSIS/Device/NXP/LPC11xx/Source/: system_LPC11xx.c
  group modules
    modules/: drv_hd44780.c drv_hd44780_l.c
