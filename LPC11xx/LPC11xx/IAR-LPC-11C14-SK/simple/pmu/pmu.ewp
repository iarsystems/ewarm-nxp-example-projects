# IAR project pmu.ewp, settings and files
configuration Flash debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11C14 NXP LPC11C14
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __DEBUG_FLASH
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\Core\Include; ..\Common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: pmu.c pmutest.c
    ../: readme.txt
  group Common
    ../Common/src/: clkconfig.c cstartup_M.s gpio.c system_LPC11xx.c timer16.c timer32.c uart.c
