# IAR project USBMouse_USBROMD.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U24FBD64_401 NXP LPC11U24FBD64_401
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_11U24_SK
  ICCARM.CCIncludePath2: ; app; board; modules; USBROMD
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBMouse.srec
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s main.c readme.txt
  group modules
    modules/: drv_hd44780.c drv_hd44780_l.c
    app/: usb_cnfg.h usb_desc.c usb_hid_mouse.c
  group USBROMD
    USBROMD/: error.h mw_usbd.h mw_usbd_adcuser.h mw_usbd_audio.h mw_usbd_cdc.h mw_usbd_cdcuser.h mw_usbd_core.h mw_usbd_desc.h mw_usbd_dfu.h mw_usbd_dfuuser.h mw_usbd_hid.h mw_usbd_hiduser.h mw_usbd_hw.h mw_usbd_msc.h mw_usbd_mscuser.h mw_usbd_rom_api.h
