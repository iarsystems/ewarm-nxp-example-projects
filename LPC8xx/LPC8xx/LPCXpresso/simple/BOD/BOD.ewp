# IAR project BOD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC812M101 NXP LPC812M101
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\Core\Include; ..\Common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: BOD.out
  group (top)
    ./: Abstract.txt bodtest.c
  group Common
    ../Common/src/: cstartup_M.s lpc8xx_bod.c lpc8xx_gpio.c lpc8xx_mrt.c lpc8xx_pmu.c system_LPC8xx.c
