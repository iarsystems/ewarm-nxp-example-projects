# IAR project usart_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC812M101 NXP LPC812M101
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\Core\Include; ..\Common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: usart_master.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract_usart_master.txt usartms.c
  group Common
    ../Common/src/: cstartup_M.s lpc8xx_gpio.c lpc8xx_uart.c system_LPC8xx.c
