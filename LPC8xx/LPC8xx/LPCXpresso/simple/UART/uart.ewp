# IAR project uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC812M101 NXP LPC812M101
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\Core\Include; ..\Common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt uarttest.c
  group Common
    ../Common/src/: cstartup_M.s lpc8xx_clkconfig.c lpc8xx_uart.c system_LPC8xx.c
