# IAR project SCT_Event_Counter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC844M201 NXP LPC844M201
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; inc; ..\peripherals_lib\inc; ..\utilities_lib\inc; ..\common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADC_Seqa_Seqb.out
  ILINK.IlinkAdditionalLibs: ..\utilities_lib\utilities_lib.a; ..\peripherals_lib\peripherals_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\peripherals_lib\peripherals_lib.a; ..\utilities_lib\utilities_lib.a
  group (top)
    ./: README.txt
  group common/src
    ../common/src/: IAR_cstartup_M.s IAR_Redirect.c Serial.c system.c
  group inc
    inc/: chip_setup.h SCT_Event_Counter.h
  group src
    src/: SCT_Event_Counter_funcs.c SCT_Event_Counter_main.c
