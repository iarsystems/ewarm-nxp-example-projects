# IAR project utilities_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC844M201 NXP LPC844M201
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; inc\; ..\common\inc\; ..\peripherals_lib\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: utilities_lib.out
  group ext/inc
    ../peripherals_lib/inc/: syscon.h
  group inc
    inc/: board.h FlashFaimPrg.h iap.h rom_api.h utilities.h
  group src
    src/: FlashFaimPrg.c utilities.c
