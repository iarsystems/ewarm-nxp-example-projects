# IAR project peripheral_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC844M201 NXP LPC844M201
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; inc; ..\common\inc; ..\utilities_lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: peripheral_lib.out
  group ext/inc
    ../utilities_lib/inc/: utilities.h
  group inc
    inc/: acomp.h adc.h ctimer.h dac.h dma.h faim.h fro.h gpio.h i2c.h inmux_trigmux.h iocon.h mrt.h pmu.h sct.h spi.h swm.h syscon.h uart.h wkt.h wwdt.h
  group src
    src/: gpio.c i2c.c swm.c syscon.c
