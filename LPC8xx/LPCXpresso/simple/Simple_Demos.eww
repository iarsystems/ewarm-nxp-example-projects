<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Blinky/blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/BOD/BOD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/comparator/comparator.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC/CRC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/gpio/gpio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/i2c/i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pmu/pmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI/spi_master/spi_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI/spi_slave/spi_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/systick/systick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART/uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART/usart_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART/usart_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/wdt/wdt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/wkt/wkt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>BOD</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>comparator</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CRC</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>i2c</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>pmu</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>spi_master</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>spi_slave</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>systick</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usart_master</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usart_slave</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>wdt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>wkt</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
