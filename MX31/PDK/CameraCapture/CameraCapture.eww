<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CameraCapture.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CameraCapture</project>
        <configuration>NAND_DEBUG</configuration>
      </member>
      <member>
        <project>CameraCapture</project>
        <configuration>SDRAM_DEBUG</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
