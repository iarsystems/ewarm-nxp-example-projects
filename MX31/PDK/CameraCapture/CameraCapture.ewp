# IAR project CameraCapture.ewp, settings and files
configuration SDRAM_DEBUG (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MCIMX31 NXP MCIMX31
  ICCARM.CCDefines: SDRAM_DEBUG
  ICCARM.CCIncludePath2: board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: CameraCapture.out
  ILINK.IlinkIcfFile: config/mcimx31_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NAND_DEBUG (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX31_PDK NXP MCIMX31_PDK
  group (top)
    ./: readme.txt
  group app
    app/: main.c menu_bmp.c
  group board
    board/: bootloader.c bootstartup.s ttbl.c
  group modules
    modules/: arm1136jf_cp15_drv.c drv_aitc.c drv_atlas.c drv_csi.c drv_i2c1.c drv_ipu.c drv_lcd.c drv_touch_scr.c
