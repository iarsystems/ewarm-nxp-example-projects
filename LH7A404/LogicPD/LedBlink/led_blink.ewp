# IAR project led_blink.ewp, settings and files
configuration DebugRunFromFlash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LH7A404LPDSDK NXP LH7A404LPDSDK
  ICCARM.CCDefines: RUN_FROM_FLASH
  ICCARM.CCIncludePath2: ; board\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: led_blink.out
  ILINK.IlinkIcfFile: config/StandAloneFlashLH7A404LPD.icf
  group (top)
    ./: main.c
  group Common
    board/: arm922t_cp15_drv.c cstartup.s lh7A404_low_init.c ttbl.c
