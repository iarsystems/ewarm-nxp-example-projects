# IAR project BasicLcd.ewp, settings and files
configuration DebugRunFromFlash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LH7A404LPDSDK NXP LH7A404LPDSDK
  ICCARM.CCDefines: RUN_FROM_FLASH
  ICCARM.CCIncludePath2: ; app\; board\; modules\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: BasicLcd.out
  ILINK.IlinkIcfFile: config/StandAloneFlashLH7A404LPD.icf
  group (top)
    app/: main.c Paint_bmp.c
  group Common
    board/: arm922t_cp15_drv.c cstartup.s lh7A404_low_init.c ttbl.c
  group Modules
    modules/: lcd_drv.c lh7A40x_vic.c lq035q7db02_lcd.c touch_scr.c
