# IAR project Pgm2106.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Pgm2106.out
  ILINK.IlinkIcfFile: Pgm_v01.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Pgm2106.hex
  group (top)
    ./: Easypgm.c Editor.c Extra.c ma_gpio.c ma_i2c.c ma_pcb.c ma_spi.c ma_uart1.c Pgm24c.c Pgm25c.c
