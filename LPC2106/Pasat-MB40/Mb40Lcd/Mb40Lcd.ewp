# IAR project Mb40Lcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __THUMB_LIBRARY__
  ILINK.IlinkOutputFile: Mb40Lcd.out
  ILINK.IlinkIcfFile: PGM_V01.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Mb40Lcd.hex
  group (top)
    ./: Clock.c Editor.c Em6125.c Extra.c Interupt.c Key_api.c Lcd.c Lcd_api.c Led.c ma_gpio.c ma_i2c.c ma_pcb.c ma_rtc.c ma_scb.c ma_spi.c ma_tmr.c ma_uart0.c ma_vic.c MB40LCD1.C My_files.c PGM24C.C PGM25C.C PllTurbo.c Ta_read.c TA_WRITE.C
