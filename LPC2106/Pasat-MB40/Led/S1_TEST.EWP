# IAR project S1_TEST.EWP, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __THUMB_LIBRARY__
  OBJCOPY.OOCOutputFile: S1_TEST.srec
  ILINK.IlinkOutputFile: S1_TEST.out
  ILINK.IlinkIcfFile: RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: ma_gpio.c ma_pcb.c ma_scb.c S1_Led.c S1_Main.c
