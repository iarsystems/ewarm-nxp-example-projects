# IAR project UARTEcho.ewp, settings and files
configuration ROM-monitor (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: ROM_MONITOR_DEBUG
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __THUMB_LIBRARY__=1
  ILINK.IlinkOutputFile: UARTEcho.out
  ILINK.IlinkIcfFile: LPC2106_ROMmonitor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration JLink (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: JTAG_DEBUG
  OBJCOPY.OOCOutputFile: UARTEcho.hex
  ILINK.IlinkIcfFile: LPC2106_JLink.icf
configuration Standalone (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __STANDALONE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: LPC2106_Standalone.icf
  group (top)
    ./: lpc210x.c UARTEcho.c
