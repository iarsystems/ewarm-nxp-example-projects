<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RunningLights.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Shoot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UARTEcho.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>RunningLights</project>
        <configuration>JLink</configuration>
      </member>
      <member>
        <project>RunningLights</project>
        <configuration>ROM-monitor</configuration>
      </member>
      <member>
        <project>RunningLights</project>
        <configuration>Standalone</configuration>
      </member>
      <member>
        <project>Shoot</project>
        <configuration>JLink</configuration>
      </member>
      <member>
        <project>Shoot</project>
        <configuration>ROM-monitor</configuration>
      </member>
      <member>
        <project>Shoot</project>
        <configuration>Standalone</configuration>
      </member>
      <member>
        <project>UARTEcho</project>
        <configuration>JLink</configuration>
      </member>
      <member>
        <project>UARTEcho</project>
        <configuration>ROM-monitor</configuration>
      </member>
      <member>
        <project>UARTEcho</project>
        <configuration>Standalone</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
