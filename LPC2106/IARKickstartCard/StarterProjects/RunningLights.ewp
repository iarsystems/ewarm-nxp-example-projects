# IAR project RunningLights.ewp, settings and files
configuration JLink (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: JTAG_DEBUG
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __THUMB_LIBRARY__=1
  ILINK.IlinkOutputFile: RunningLights.out
  ILINK.IlinkIcfFile: LPC2106_JLink.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ROM-monitor (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ROM_MONITOR_DEBUG
  ILINK.IlinkIcfFile: LPC2106_ROMmonitor.icf
configuration Standalone (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __STANDALONE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: RunningLights.srec
  ILINK.IlinkIcfFile: LPC2106_Standalone.icf
  group (top)
    ./: lpc210x.c runninglights.c timer.c
