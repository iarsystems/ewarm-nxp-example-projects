# IAR project Ex_Ram210x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_DEBUG
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ARM_LIBRARY__=1
  OBJCOPY.OOCOutputFile: Ex_Ram210x.srec
  ILINK.IlinkOutputFile: Ex_Ram210x.out
  ILINK.IlinkIcfFile: RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lpc210x.c main.c timer.c
