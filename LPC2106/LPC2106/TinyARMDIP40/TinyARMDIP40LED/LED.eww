<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Ex_Ram210x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Ex_Flash2106.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Ex_Flash2106</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>Ex_Flash2106</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>Ex_Ram210x</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


