# IAR project Ex_Flash2106.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EXEC_FLASH
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ARM_LIBRARY__=1
  OBJCOPY.OOCOutputFile: Ex_Flash2106.srec
  ILINK.IlinkOutputFile: Ex_Flash2106.out
  ILINK.IlinkIcfFile: Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Ex_Flash2106.hex
  group (top)
    ./: lpc210x.c main.c timer.c
