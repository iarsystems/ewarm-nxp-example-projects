# IAR project evba7.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ARM_LIBRARY__=1
  ILINK.IlinkOutputFile: evba7.out
  ILINK.IlinkIcfFile: evba7.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lpc210x.c main.c readme.txt timer.c
