# IAR project Usb_Composite.ewp, settings and files
configuration Internal SRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=1; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC18xx\Include; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Burst.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Internal Flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  OBJCOPY.OOCOutputFile: adc_burst.srec
configuration Hitex NOR (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: adc_burst.srec
  ILINK.IlinkIcfFile: ../../../../Core/Device/NXP/LPC18xx/IAR support/config/Hitex_LPC1850_NOR.icf
configuration SPIFI Flash (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: adc_burst.srec
  ILINK.IlinkIcfFile: ../../../../Core/Device/NXP/LPC18xx/IAR support/config/Hitex_LPC1850_SPIFI.icf
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC18xx/Source/Templates/: system_LPC18xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc18xx_cgu.c lpc18xx_scu.c lpc18xx_timer.c lpc18xx_uart.c
  group Main
    ../: composite_usbdesc.c config.h lpc18xx_libcfg.h main.c usbd_cdc.c usbd_dfu.c usbd_hid.c usbd_msc_mem.c
  group Readme
    ../: Abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC18xx/Source/Templates/IAR/: startup_LPC18xx.s
