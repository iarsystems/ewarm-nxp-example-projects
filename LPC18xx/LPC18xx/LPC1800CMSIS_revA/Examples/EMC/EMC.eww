<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Emc_NorFlash/EWARM/Emc_NorFlash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Emc_Sdram/EWARM/Emc_Sdram.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Emc_NorFlash</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Emc_NorFlash</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Emc_NorFlash</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Emc_NorFlash</project>
        <configuration>SPIFI Flash</configuration>
      </member>
      <member>
        <project>Emc_Sdram</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Emc_Sdram</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Emc_Sdram</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Emc_Sdram</project>
        <configuration>SPIFI Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
