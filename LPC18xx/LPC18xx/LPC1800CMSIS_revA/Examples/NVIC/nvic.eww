<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Nvic_Priorities/EWARM/Nvic_Priorities.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Nvic_VectorTableRelocation/EWARM/Nvic_VectorTableRelocation.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Nvic_Priorities</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Nvic_Priorities</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Nvic_Priorities</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Nvic_Priorities</project>
        <configuration>SPIFI Flash</configuration>
      </member>
      <member>
        <project>Nvic_VectorTableRelocation</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Nvic_VectorTableRelocation</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Nvic_VectorTableRelocation</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Nvic_VectorTableRelocation</project>
        <configuration>SPIFI Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
