<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2c_Master/EWARM/I2c_Master.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>I2c_Master</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>I2c_Master</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
