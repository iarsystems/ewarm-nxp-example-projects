# IAR project Usb_Cdc.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC1850rev- NXP LPC1850rev-
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=1; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC18xx; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC18xx\startup\iar; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_burst.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../Core/CM3/DeviceSupport/NXP/LPC18xx/IAR support/ldscript_iram2_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../Core/CM3/DeviceSupport/NXP/LPC18xx/: system_LPC18xx.c
  group Drivers
    ../../../../Drivers/source/: lpc18xx_cgu.c lpc18xx_scu.c
  group Main
    ../: cdcuser.c serial.c usbcore.c usbdesc.c usbhw.c usbuser.c vcomdemo.c
  group Readme
    ../: Abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC18xx/startup/iar/: startup_LPC18xx.s
