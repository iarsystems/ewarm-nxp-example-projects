# IAR project Nvic_VectorTableRelocation.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC1850rev- NXP LPC1850rev-
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=1; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC18xx; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC18xx\startup\iar; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_burst.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../Core/CM3/DeviceSupport/NXP/LPC18xx/IAR support/ldscript_iram_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration EXFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__=0; __BUILD_WITH_EXAMPLE__=1
  ILINK.IlinkIcfFile: ../../../../Core/CM3/DeviceSupport/NXP/LPC18xx/IAR support/ldscript_exflash_iar.icf
  group CMSIS-CM3
    ../../../../Core/CM3/DeviceSupport/NXP/LPC18xx/: system_LPC18xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc18xx_cgu.c lpc18xx_dac.c lpc18xx_gpio.c lpc18xx_nvic.c lpc18xx_scu.c lpc18xx_timer.c lpc18xx_uart.c
  group Main
    ../: Nvic_VectorTableRelocation.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC18xx/startup/iar/: startup_LPC18xx.s
