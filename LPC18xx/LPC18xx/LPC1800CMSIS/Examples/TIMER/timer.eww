<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Timer_Capture/EWARM/Timer_Capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Timer_FreqMeasure/EWARM/Timer_FreqMeasure.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Timer_MatchInterrupt/EWARM/Timer_MatchInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Timer_MatchPolling/EWARM/Timer_MatchPolling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Timer_Capture</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Timer_Capture</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Timer_FreqMeasure</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Timer_FreqMeasure</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Timer_MatchInterrupt</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Timer_MatchInterrupt</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Timer_MatchPolling</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Timer_MatchPolling</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
