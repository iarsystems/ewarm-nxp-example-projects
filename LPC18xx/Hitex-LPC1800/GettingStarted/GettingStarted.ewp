# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: HITEX_LPC_1800
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SRAM
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/LPC1850_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NOR Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/Hitex_LPC1850_NOR.icf
configuration SPIFI Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/Hitex_LPC1850_SPIFI.icf
configuration iFlash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  group (top)
    ./: cstartup_M.s i2c_drv.c main.c readme.txt
