<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Rit_Interrupt/EWARM/Rit_Interrupt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Rit_Interrupt</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Rit_Interrupt</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
