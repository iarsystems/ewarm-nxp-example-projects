<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Adc_Burst/EWARM/Adc_Burst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Adc_Dma/EWARM/Adc_Dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Adc_Interrupt/EWARM/Adc_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Adc_Polling/EWARM/Adc_Polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Adc_Burst</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Adc_Burst</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Adc_Dma</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Adc_Dma</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Adc_Interrupt</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Adc_Interrupt</project>
        <configuration>RAM</configuration>
      </member>
      <member>
        <project>Adc_Polling</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Adc_Polling</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
