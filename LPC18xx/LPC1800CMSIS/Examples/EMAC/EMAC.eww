<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Emac_EasyWeb/EWARM/Emac_EasyWeb.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Emac_EasyWeb</project>
        <configuration>EXFLASH</configuration>
      </member>
      <member>
        <project>Emac_EasyWeb</project>
        <configuration>RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
