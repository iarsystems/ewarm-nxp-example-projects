<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Wdt_Interrupt/EWARM/Wdt_Interrupt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Wdt_Interrupt</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Wdt_Interrupt</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Wdt_Interrupt</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Wdt_Interrupt</project>
        <configuration>SPIFI Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
