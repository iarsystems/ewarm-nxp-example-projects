<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Sct_SimpleMatch/EWARM/Sct_SimpleMatch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Sct_SimpleMatch</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Sct_SimpleMatch</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Sct_SimpleMatch</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Sct_SimpleMatch</project>
        <configuration>SPIFI Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
