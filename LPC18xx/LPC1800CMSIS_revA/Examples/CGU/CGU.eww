<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CGU_measureFreq/EWARM/CGU_measureFreq.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CGU_measureFreq</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>CGU_measureFreq</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>CGU_measureFreq</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>CGU_measureFreq</project>
        <configuration>SPIFI Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
