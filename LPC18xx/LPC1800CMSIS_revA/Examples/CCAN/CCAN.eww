<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CCan_SimpleTxRx/EWARM/CCan_SimpleTxRx.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CCan_SimpleTxRx</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>CCan_SimpleTxRx</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>CCan_SimpleTxRx</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>CCan_SimpleTxRx</project>
        <configuration>SPIFI Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
