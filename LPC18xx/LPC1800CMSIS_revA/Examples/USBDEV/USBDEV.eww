<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Usb_Cdc/EWARM/Usb_Cdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Usb_MassStorage/EWARM/Usb_MassStorage.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Usb_Cdc</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Usb_Cdc</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Usb_Cdc</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Usb_Cdc</project>
        <configuration>SPIFI Flash</configuration>
      </member>
      <member>
        <project>Usb_MassStorage</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Usb_MassStorage</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Usb_MassStorage</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Usb_MassStorage</project>
        <configuration>SPIFI Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
