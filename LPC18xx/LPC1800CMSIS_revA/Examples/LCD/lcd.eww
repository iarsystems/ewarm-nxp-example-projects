<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Lcd_Demo/EWARM/Lcd_Demo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Lcd_Demo</project>
        <configuration>Hitex NOR</configuration>
      </member>
      <member>
        <project>Lcd_Demo</project>
        <configuration>Internal Flash</configuration>
      </member>
      <member>
        <project>Lcd_Demo</project>
        <configuration>Internal SRAM</configuration>
      </member>
      <member>
        <project>Lcd_Demo</project>
        <configuration>SPIFI Flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
