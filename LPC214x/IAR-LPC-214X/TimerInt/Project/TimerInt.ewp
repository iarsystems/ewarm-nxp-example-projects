# IAR project TimerInt.ewp, settings and files
configuration JLINK_RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC2148 Philips LPC2148
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkOutputFile: TimerInt.out
  ILINK.IlinkIcfFile: ../Configuration/LPC2148_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration JLINK_FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../Configuration/LPC2148_FLASH.icf
  group (top)
    ../Source/: lpc2xxx_cstartup.s Timer0_IntOnMR0.c
  group Documentation
    ../: readme.txt
