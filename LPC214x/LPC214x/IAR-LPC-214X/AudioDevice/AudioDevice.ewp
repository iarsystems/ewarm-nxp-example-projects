# IAR project AudioDevice.ewp, settings and files
configuration FlashDebug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; app; board; modules
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: AudioDevice.out
  ILINK.IlinkIcfFile: config/Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c
  group Common
    board/: cstartup.s
  group Module
    modules/: drv_hd44780.c drv_hd44780_l.c lpc_syscontrol.c lpc_timer.c lpc_vic.c
  group USB/Class
    app/: audio_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
