# IAR project USBMouse.ewp, settings and files
configuration Debug Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: FLASH
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: USBMouse.out
  ILINK.IlinkIcfFile: config/Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug RAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2148 Philips LPC2148
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkIcfFile: config/RAM.icf
  group (top)
    app/: demo_usb.c user_func.c
  group Common Source
    board/: cstartup.s
  group Module Source
    modules/: drv_hd44780.c drv_hd44780_l.c LPC_SysControl.c LPC_Timer.c LPC_Vic.c
  group USB/Class
    app/: hid_mouse.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
