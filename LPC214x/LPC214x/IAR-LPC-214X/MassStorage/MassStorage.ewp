# IAR project MassStorage.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; app; board; modules
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MassStorage.out
  ILINK.IlinkIcfFile: config/Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c
  group Common
    board/: cstartup.s
  group HD44780
    modules/: drv_hd44780.c drv_hd44780_cnfg.h drv_hd44780_l.c
  group Luns
    app/: lun.c
  group Luns/RAM
    app/: ram_dsk.c ram_dsk_desc.c
  group Luns/SD/MMC
    app/: sd_dsk_desc.c sd_ll_spi1.c sd_spi_mode.c
  group Module
    modules/: lpc_syscontrol.c lpc_timer.c LPC_Vic.c
  group USB/Class
    app/: scsi.c scsi_ll.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
